   button "Add to Search History" "do &dp_cmm_path\PER_Print XPU_CFG_RPM_CFG_XPU_SESYNR2 PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   2.           "[ 2 ]      MODEM_PRT_HIT                       = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   1.           "[ 1 ]      SECURE_PRT_HIT                      = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   0.           "[ 0 ]      NONSECURE_PRT_HIT                   = " "0x00 (?),0x01 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00033058$ PER_TESLA9X45_Part5.per -queue XPU_CFG_RPM_CFG_XPU_SESYNR2"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00033100
tree " XPU_CFG_RPM_CFG_XPU_MCR [RW]                                      0x00033100"
  group.long 0x0--0x3
   textline "POR 0x00000106    MASK = 0x0000071F    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print XPU_CFG_RPM_CFG_XPU_MCR PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   10.          "[ 10 ]     CLEIE                               = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   9.           "[ 9 ]      CFGEIE                              = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   8.           "[ 8 ]      DYNAMIC_CLK_EN                      = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   4.           "[ 4 ]      DCDEE                               = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   3.           "[ 3 ]      EIE                                 = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   2.           "[ 2 ]      CLERE                               = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   1.           "[ 1 ]      CFGERE                              = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   0.           "[ 0 ]      XPUMSAE                             = " "0x00 (?),0x01 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00033100$ PER_TESLA9X45_Part5.per -queue XPU_CFG_RPM_CFG_XPU_MCR"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00033140
tree " XPU_CFG_RPM_CFG_XPU_MEAR0 [R]                                     0x00033140"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0xFFFFFFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print XPU_CFG_RPM_CFG_XPU_MEAR0 PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.long 0 0.--31. 1  "[31 : 0]   PA                                  = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00033140$ PER_TESLA9X45_Part5.per -queue XPU_CFG_RPM_CFG_XPU_MEAR0"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00033148
tree " XPU_CFG_RPM_CFG_XPU_MESR [RW]                                     0x00033148"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x8000000F    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print XPU_CFG_RPM_CFG_XPU_MESR PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   31.          "[ 31 ]     MULTI                               = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   3.           "[ 3 ]      CLMULTI                             = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   2.           "[ 2 ]      CFGMULTI                            = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   1.           "[ 1 ]      CLIENT                              = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   0.           "[ 0 ]      CFG                                 = " "0x00 (?),0x01 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00033148$ PER_TESLA9X45_Part5.per -queue XPU_CFG_RPM_CFG_XPU_MESR"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0003314C
tree " XPU_CFG_RPM_CFG_XPU_MESRRESTORE [RW]                              0x0003314C"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x8000000F    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print XPU_CFG_RPM_CFG_XPU_MESRRESTORE PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   31.          "[ 31 ]     MULTI                               = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   3.           "[ 3 ]      CLMULTI                             = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   2.           "[ 2 ]      CFGMULTI                            = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   1.           "[ 1 ]      CLIENT                              = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   0.           "[ 0 ]      CFG                                 = " "0x00 (?),0x01 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0003314C$ PER_TESLA9X45_Part5.per -queue XPU_CFG_RPM_CFG_XPU_MESRRESTORE"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00033150
tree " XPU_CFG_RPM_CFG_XPU_MESYNR0 [R]                                   0x00033150"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0xFFFFFFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print XPU_CFG_RPM_CFG_XPU_MESYNR0 PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.byte 0 24.--31. 1 "[31 : 24]  ATID                                = "
   textline ""
   hexmask.long.byte 0 16.--23. 1 "[23 : 16]  AVMID                               = "
   textline ""
   bitfld.long 0x0   13.--15.     "[15 : 13]  ABID                                = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?)"
   textline ""
   bitfld.long 0x0   8.--12.      "[12 : 8]   APID                                = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?),0x08 (?),0x09 (?),0x0A (?),0x0B (?),0x0C (?),0x0D (?),0x0E (?),0x0F (?),0x10 (?),0x11 (?),0x12 (?),0x13 (?),0x14 (?),0x15 (?),0x16 (?),0x17 (?),0x18 (?),0x19 (?),0x1A (?),0x1B (?),0x1C (?),0x1D (?),0x1E (?),0x1F (?)"
   textline ""
   hexmask.long.byte 0 0.--7. 1   "[7 : 0]    AMID                                = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00033150$ PER_TESLA9X45_Part5.per -queue XPU_CFG_RPM_CFG_XPU_MESYNR0"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00033154
tree " XPU_CFG_RPM_CFG_XPU_MESYNR1 [R]                                   0x00033154"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0xFFFFFFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print XPU_CFG_RPM_CFG_XPU_MESYNR1 PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   31.          "[ 31 ]     DCD                                 = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   30.          "[ 30 ]     AC                                  = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   29.          "[ 29 ]     BURSTLEN                            = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   28.          "[ 28 ]     ARDALLOCATE                         = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   27.          "[ 27 ]     ABURST                              = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   26.          "[ 26 ]     AEXCLUSIVE                          = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   25.          "[ 25 ]     AWRITE                              = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   24.          "[ 24 ]     AFULL                               = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   23.          "[ 23 ]     ARDBEADNDXEN                        = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   22.          "[ 22 ]     AOOO                                = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   19.--21.     "[21 : 19]  APREQPRIORITY                       = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?)"
   textline ""
   bitfld.long 0x0   16.--18.     "[18 : 16]  ASIZE                               = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?)"
   textline ""
   bitfld.long 0x0   15.          "[ 15 ]     AMSSSELFAUTH                        = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   8.--14.      "[14 : 8]   ALEN                                = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?),0x08 (?),0x09 (?),0x0A (?),0x0B (?),0x0C (?),0x0D (?),0x0E (?),0x0F (?),0x10 (?),0x11 (?),0x12 (?),0x13 (?),0x14 (?),0x15 (?),0x16 (?),0x17 (?),0x18 (?),0x19 (?),0x1A (?),0x1B (?),0x1C (?),0x1D (?),0x1E (?),0x1F (?),0x20 (?),0x21 (?),0x22 (?),0x23 (?),0x24 (?),0x25 (?),0x26 (?),0x27 (?),0x28 (?),0x29 (?),0x2A (?),0x2B (?),0x2C (?),0x2D (?),0x2E (?),0x2F (?),0x30 (?),0x31 (?),0x32 (?),0x33 (?),0x34 (?),0x35 (?),0x36 (?),0x37 (?),0x38 (?),0x39 (?),0x3A (?),0x3B (?),0x3C (?),0x3D (?),0x3E (?),0x3F (?),0x40 (?),0x41 (?),0x42 (?),0x43 (?),0x44 (?),0x45 (?),0x46 (?),0x47 (?),0x48 (?),0x49 (?),0x4A (?),0x4B (?),0x4C (?),0x4D (?),0x4E (?),0x4F (?),0x50 (?),0x51 (?),0x52 (?),0x53 (?),0x54 (?),0x55 (?),0x56 (?),0x57 (?),0x58 (?),0x59 (?),0x5A (?),0x5B (?),0x5C (?),0x5D (?),0x5E (?),0x5F (?),0x60 (?),0x61 (?),0x62 (?),0x63 (?),0x64 (?),0x65 (?),0x66 (?),0x67 (?),0x68 (?),0x69 (?),0x6A (?),0x6B (?),0x6C (?),0x6D (?),0x6E (?),0x6F (?),0x70 (?),0x71 (?),0x72 (?),0x73 (?),0x74 (?),0x75 (?),0x76 (?),0x77 (?),0x78 (?),0x79 (?),0x7A (?),0x7B (?),0x7C (?),0x7D (?),0x7E (?),0x7F (?)"
   textline ""
   bitfld.long 0x0   7.           "[ 7 ]      AINST                               = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   6.           "[ 6 ]      APROTNS                             = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   5.           "[ 5 ]      APRIV                               = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   4.           "[ 4 ]      AINNERSHARED                        = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   3.           "[ 3 ]      ASHARED                             = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   0.--2.       "[2 : 0]    AMEMTYPE                            = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00033154$ PER_TESLA9X45_Part5.per -queue XPU_CFG_RPM_CFG_XPU_MESYNR1"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00033158
tree " XPU_CFG_RPM_CFG_XPU_MESYNR2 [R]                                   0x00033158"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x00000007    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print XPU_CFG_RPM_CFG_XPU_MESYNR2 PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   2.           "[ 2 ]      MODEM_PRT_HIT                       = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   1.           "[ 1 ]      SECURE_PRT_HIT                      = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   0.           "[ 0 ]      NONSECURE_PRT_HIT                   = " "0x00 (?),0x01 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00033158$ PER_TESLA9X45_Part5.per -queue XPU_CFG_RPM_CFG_XPU_MESYNR2"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00033080
tree " XPU_CFG_RPM_CFG_XPU_CR [RW]                                       0x00033080"
  group.long 0x0--0x3
   textline "POR 0x00000106    MASK = 0x0001071F    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print XPU_CFG_RPM_CFG_XPU_CR PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   16.          "[ 16 ]     MSAE                                = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   10.          "[ 10 ]     CLEIE                               = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   9.           "[ 9 ]      CFGEIE                              = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   8.           "[ 8 ]      DYNAMIC_CLK_EN                      = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   4.           "[ 4 ]      DCDEE                               = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   3.           "[ 3 ]      EIE                                 = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   2.           "[ 2 ]      CLERE                               = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   1.           "[ 1 ]      CFGERE                              = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   0.           "[ 0 ]      XPUVMIDE                            = " "0x00 (?),0x01 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00033080$ PER_TESLA9X45_Part5.per -queue XPU_CFG_RPM_CFG_XPU_CR"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00033088
tree " XPU_CFG_RPM_CFG_XPU_PRTN_RACR_SHADOW [RW]                         0x00033088"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0xFFFFFFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print XPU_CFG_RPM_CFG_XPU_PRTN_RACR_SHADOW PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.long 0 0.--31. 1  "[31 : 0]   RE                                  = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00033088$ PER_TESLA9X45_Part5.per -queue XPU_CFG_RPM_CFG_XPU_PRTN_RACR_SHADOW"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0003308C
tree " XPU_CFG_RPM_CFG_XPU_PRTN_WACR_SHADOW [RW]                         0x0003308C"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0xFFFFFFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print XPU_CFG_RPM_CFG_XPU_PRTN_WACR_SHADOW PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.long 0 0.--31. 1  "[31 : 0]   WE                                  = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0003308C$ PER_TESLA9X45_Part5.per -queue XPU_CFG_RPM_CFG_XPU_PRTN_WACR_SHADOW"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00033090
tree " XPU_CFG_RPM_CFG_XPU_PRTN_START_SHADOW0 [RW]                       0x00033090"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x003FF000    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print XPU_CFG_RPM_CFG_XPU_PRTN_START_SHADOW0 PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.word 0 12.--21. 1 "[21 : 12]  ADDR                                = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00033090$ PER_TESLA9X45_Part5.per -queue XPU_CFG_RPM_CFG_XPU_PRTN_START_SHADOW0"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00033098
tree " XPU_CFG_RPM_CFG_XPU_PRTN_END_SHADOW0 [RW]                         0x00033098"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x003FF000    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print XPU_CFG_RPM_CFG_XPU_PRTN_END_SHADOW0 PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.word 0 12.--21. 1 "[21 : 12]  ADDR                                = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00033098$ PER_TESLA9X45_Part5.per -queue XPU_CFG_RPM_CFG_XPU_PRTN_END_SHADOW0"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x000330A0
tree " XPU_CFG_RPM_CFG_XPU_RPU_ACR0 [RW] n[0:0]                          0x000330A0"
  group.long 0x0--0x3
   textline "POR 0xFFFFFFFF    MASK = 0xFFFFFFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print XPU_CFG_RPM_CFG_XPU_RPU_ACR0 PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.long 0 0.--31. 1  "[31 : 0]   RWE                                 = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x000330A0$ PER_TESLA9X45_Part5.per -queue XPU_CFG_RPM_CFG_XPU_RPU_ACR0"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x000330C0
tree " XPU_CFG_RPM_CFG_XPU_EAR0 [R]                                      0x000330C0"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0xFFFFFFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print XPU_CFG_RPM_CFG_XPU_EAR0 PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.long 0 0.--31. 1  "[31 : 0]   PA                                  = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x000330C0$ PER_TESLA9X45_Part5.per -queue XPU_CFG_RPM_CFG_XPU_EAR0"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x000330C8
tree " XPU_CFG_RPM_CFG_XPU_ESR [RW]                                      0x000330C8"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x8000000F    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print XPU_CFG_RPM_CFG_XPU_ESR PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   31.          "[ 31 ]     MULTI                               = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   3.           "[ 3 ]      CLMULTI                             = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   2.           "[ 2 ]      CFGMULTI                            = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   1.           "[ 1 ]      CLIENT                              = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   0.           "[ 0 ]      CFG                                 = " "0x00 (?),0x01 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x000330C8$ PER_TESLA9X45_Part5.per -queue XPU_CFG_RPM_CFG_XPU_ESR"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x000330CC
tree " XPU_CFG_RPM_CFG_XPU_ESRRESTORE [RW]                               0x000330CC"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x8000000F    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print XPU_CFG_RPM_CFG_XPU_ESRRESTORE PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   31.          "[ 31 ]     MULTI                               = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   3.           "[ 3 ]      CLMULTI                             = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   2.           "[ 2 ]      CFGMULTI                            = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   1.           "[ 1 ]      CLIENT                              = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   0.           "[ 0 ]      CFG                                 = " "0x00 (?),0x01 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x000330CC$ PER_TESLA9X45_Part5.per -queue XPU_CFG_RPM_CFG_XPU_ESRRESTORE"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x000330D0
tree " XPU_CFG_RPM_CFG_XPU_ESYNR0 [R]                                    0x000330D0"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0xFFFFFFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print XPU_CFG_RPM_CFG_XPU_ESYNR0 PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.byte 0 24.--31. 1 "[31 : 24]  ATID                                = "
   textline ""
   hexmask.long.byte 0 16.--23. 1 "[23 : 16]  AVMID                               = "
   textline ""
   bitfld.long 0x0   13.--15.     "[15 : 13]  ABID                                = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?)"
   textline ""
   bitfld.long 0x0   8.--12.      "[12 : 8]   APID                                = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?),0x08 (?),0x09 (?),0x0A (?),0x0B (?),0x0C (?),0x0D (?),0x0E (?),0x0F (?),0x10 (?),0x11 (?),0x12 (?),0x13 (?),0x14 (?),0x15 (?),0x16 (?),0x17 (?),0x18 (?),0x19 (?),0x1A (?),0x1B (?),0x1C (?),0x1D (?),0x1E (?),0x1F (?)"
   textline ""
   hexmask.long.byte 0 0.--7. 1   "[7 : 0]    AMID                                = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x000330D0$ PER_TESLA9X45_Part5.per -queue XPU_CFG_RPM_CFG_XPU_ESYNR0"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x000330D4
tree " XPU_CFG_RPM_CFG_XPU_ESYNR1 [R]                                    0x000330D4"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0xFFFFFFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print XPU_CFG_RPM_CFG_XPU_ESYNR1 PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   31.          "[ 31 ]     DCD                                 = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   30.          "[ 30 ]     AC                                  = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   29.          "[ 29 ]     BURSTLEN                            = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   28.          "[ 28 ]     ARDALLOCATE                         = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   27.          "[ 27 ]     ABURST                              = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   26.          "[ 26 ]     AEXCLUSIVE                          = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   25.          "[ 25 ]     AWRITE                              = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   24.          "[ 24 ]     AFULL                               = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   23.          "[ 23 ]     ARDBEADNDXEN                        = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   22.          "[ 22 ]     AOOO                                = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   19.--21.     "[21 : 19]  APREQPRIORITY                       = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?)"
   textline ""
   bitfld.long 0x0   16.--18.     "[18 : 16]  ASIZE                               = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?)"
   textline ""
   bitfld.long 0x0   15.          "[ 15 ]     AMSSSELFAUTH                        = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   8.--14.      "[14 : 8]   ALEN                                = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?),0x08 (?),0x09 (?),0x0A (?),0x0B (?),0x0C (?),0x0D (?),0x0E (?),0x0F (?),0x10 (?),0x11 (?),0x12 (?),0x13 (?),0x14 (?),0x15 (?),0x16 (?),0x17 (?),0x18 (?),0x19 (?),0x1A (?),0x1B (?),0x1C (?),0x1D (?),0x1E (?),0x1F (?),0x20 (?),0x21 (?),0x22 (?),0x23 (?),0x24 (?),0x25 (?),0x26 (?),0x27 (?),0x28 (?),0x29 (?),0x2A (?),0x2B (?),0x2C (?),0x2D (?),0x2E (?),0x2F (?),0x30 (?),0x31 (?),0x32 (?),0x33 (?),0x34 (?),0x35 (?),0x36 (?),0x37 (?),0x38 (?),0x39 (?),0x3A (?),0x3B (?),0x3C (?),0x3D (?),0x3E (?),0x3F (?),0x40 (?),0x41 (?),0x42 (?),0x43 (?),0x44 (?),0x45 (?),0x46 (?),0x47 (?),0x48 (?),0x49 (?),0x4A (?),0x4B (?),0x4C (?),0x4D (?),0x4E (?),0x4F (?),0x50 (?),0x51 (?),0x52 (?),0x53 (?),0x54 (?),0x55 (?),0x56 (?),0x57 (?),0x58 (?),0x59 (?),0x5A (?),0x5B (?),0x5C (?),0x5D (?),0x5E (?),0x5F (?),0x60 (?),0x61 (?),0x62 (?),0x63 (?),0x64 (?),0x65 (?),0x66 (?),0x67 (?),0x68 (?),0x69 (?),0x6A (?),0x6B (?),0x6C (?),0x6D (?),0x6E (?),0x6F (?),0x70 (?),0x71 (?),0x72 (?),0x73 (?),0x74 (?),0x75 (?),0x76 (?),0x77 (?),0x78 (?),0x79 (?),0x7A (?),0x7B (?),0x7C (?),0x7D (?),0x7E (?),0x7F (?)"
   textline ""
   bitfld.long 0x0   7.           "[ 7 ]      AINST                               = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   6.           "[ 6 ]      APROTNS                             = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   5.           "[ 5 ]      APRIV                               = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   4.           "[ 4 ]      AINNERSHARED                        = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   3.           "[ 3 ]      ASHARED                             = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   0.--2.       "[2 : 0]    AMEMTYPE                            = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x000330D4$ PER_TESLA9X45_Part5.per -queue XPU_CFG_RPM_CFG_XPU_ESYNR1"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x000330D8
tree " XPU_CFG_RPM_CFG_XPU_ESYNR2 [R]                                    0x000330D8"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x00000007    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print XPU_CFG_RPM_CFG_XPU_ESYNR2 PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   2.           "[ 2 ]      MODEM_PRT_HIT                       = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   1.           "[ 1 ]      SECURE_PRT_HIT                      = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   0.           "[ 0 ]      NONSECURE_PRT_HIT                   = " "0x00 (?),0x01 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x000330D8$ PER_TESLA9X45_Part5.per -queue XPU_CFG_RPM_CFG_XPU_ESYNR2"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x000330E0
tree " XPU_CFG_RPM_CFG_XPU_UMR_RACR [RW]                                 0x000330E0"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0xFFFFFFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print XPU_CFG_RPM_CFG_XPU_UMR_RACR PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.long 0 0.--31. 1  "[31 : 0]   RE                                  = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x000330E0$ PER_TESLA9X45_Part5.per -queue XPU_CFG_RPM_CFG_XPU_UMR_RACR"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x000330E4
tree " XPU_CFG_RPM_CFG_XPU_UMR_WACR [RW]                                 0x000330E4"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0xFFFFFFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print XPU_CFG_RPM_CFG_XPU_UMR_WACR PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.long 0 0.--31. 1  "[31 : 0]   WE                                  = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x000330E4$ PER_TESLA9X45_Part5.per -queue XPU_CFG_RPM_CFG_XPU_UMR_WACR"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x000330F0
tree " XPU_CFG_RPM_CFG_XPU_UMR_CNTL [RW]                                 0x000330F0"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x00000003    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print XPU_CFG_RPM_CFG_XPU_UMR_CNTL PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   1.           "[ 1 ]      MSACLROE                            = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   0.           "[ 0 ]      MSACLRWE                            = " "0x00 (?),0x01 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x000330F0$ PER_TESLA9X45_Part5.per -queue XPU_CFG_RPM_CFG_XPU_UMR_CNTL"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00033074
tree " XPU_CFG_RPM_CFG_XPU_IDR0 [R]                                      0x00033074"
  group.long 0x0--0x3
   textline "POR 0x150C2C01    MASK = 0xFF3FBFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print XPU_CFG_RPM_CFG_XPU_IDR0 PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   31.          "[ 31 ]     CLIENTREQ_HALT_ACK_HW_EN            = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   30.          "[ 30 ]     SAVERESTORE_HW_EN                   = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   24.--29.     "[29 : 24]  MSB                                 = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?),0x08 (?),0x09 (?),0x0A (?),0x0B (?),0x0C (?),0x0D (?),0x0E (?),0x0F (?),0x10 (?),0x11 (?),0x12 (?),0x13 (?),0x14 (?),0x15 (?),0x16 (?),0x17 (?),0x18 (?),0x19 (?),0x1A (?),0x1B (?),0x1C (?),0x1D (?),0x1E (?),0x1F (?),0x20 (?),0x21 (?),0x22 (?),0x23 (?),0x24 (?),0x25 (?),0x26 (?),0x27 (?),0x28 (?),0x29 (?),0x2A (?),0x2B (?),0x2C (?),0x2D (?),0x2E (?),0x2F (?),0x30 (?),0x31 (?),0x32 (?),0x33 (?),0x34 (?),0x35 (?),0x36 (?),0x37 (?),0x38 (?),0x39 (?),0x3A (?),0x3B (?),0x3C (?),0x3D (?),0x3E (?),0x3F (?)"
   textline ""
   bitfld.long 0x0   16.--21.     "[21 : 16]  LSB                                 = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?),0x08 (?),0x09 (?),0x0A (?),0x0B (?),0x0C (?),0x0D (?),0x0E (?),0x0F (?),0x10 (?),0x11 (?),0x12 (?),0x13 (?),0x14 (?),0x15 (?),0x16 (?),0x17 (?),0x18 (?),0x19 (?),0x1A (?),0x1B (?),0x1C (?),0x1D (?),0x1E (?),0x1F (?),0x20 (?),0x21 (?),0x22 (?),0x23 (?),0x24 (?),0x25 (?),0x26 (?),0x27 (?),0x28 (?),0x29 (?),0x2A (?),0x2B (?),0x2C (?),0x2D (?),0x2E (?),0x2F (?),0x30 (?),0x31 (?),0x32 (?),0x33 (?),0x34 (?),0x35 (?),0x36 (?),0x37 (?),0x38 (?),0x39 (?),0x3A (?),0x3B (?),0x3C (?),0x3D (?),0x3E (?),0x3F (?)"
   textline ""
   bitfld.long 0x0   15.          "[ 15 ]     BLED                                = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   12.--13.     "[13 : 12]  XPUT                                = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?)"
   textline ""
   bitfld.long 0x0   11.          "[ 11 ]     PT                                  = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   10.          "[ 10 ]     MV                                  = " "0x00 (?),0x01 (?)"
   textline ""
   hexmask.long.word 0 0.--9. 1   "[9 : 0]    NRG                                 = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00033074$ PER_TESLA9X45_Part5.per -queue XPU_CFG_RPM_CFG_XPU_IDR0"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00033078
tree " XPU_CFG_RPM_CFG_XPU_IDR1 [R]                                      0x00033078"
  group.long 0x0--0x3
   textline "POR 0x1F090A1F    MASK = 0x7F3FFEFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print XPU_CFG_RPM_CFG_XPU_IDR1 PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   30.          "[ 30 ]     AMT_HW_ENABLE                       = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   24.--29.     "[29 : 24]  CLIENT_ADDR_WIDTH                   = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?),0x08 (?),0x09 (?),0x0A (?),0x0B (?),0x0C (?),0x0D (?),0x0E (?),0x0F (?),0x10 (?),0x11 (?),0x12 (?),0x13 (?),0x14 (?),0x15 (?),0x16 (?),0x17 (?),0x18 (?),0x19 (?),0x1A (?),0x1B (?),0x1C (?),0x1D (?),0x1E (?),0x1F (?),0x20 (?),0x21 (?),0x22 (?),0x23 (?),0x24 (?),0x25 (?),0x26 (?),0x27 (?),0x28 (?),0x29 (?),0x2A (?),0x2B (?),0x2C (?),0x2D (?),0x2E (?),0x2F (?),0x30 (?),0x31 (?),0x32 (?),0x33 (?),0x34 (?),0x35 (?),0x36 (?),0x37 (?),0x38 (?),0x39 (?),0x3A (?),0x3B (?),0x3C (?),0x3D (?),0x3E (?),0x3F (?)"
   textline ""
   bitfld.long 0x0   16.--21.     "[21 : 16]  CONFIG_ADDR_WIDTH                   = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?),0x08 (?),0x09 (?),0x0A (?),0x0B (?),0x0C (?),0x0D (?),0x0E (?),0x0F (?),0x10 (?),0x11 (?),0x12 (?),0x13 (?),0x14 (?),0x15 (?),0x16 (?),0x17 (?),0x18 (?),0x19 (?),0x1A (?),0x1B (?),0x1C (?),0x1D (?),0x1E (?),0x1F (?),0x20 (?),0x21 (?),0x22 (?),0x23 (?),0x24 (?),0x25 (?),0x26 (?),0x27 (?),0x28 (?),0x29 (?),0x2A (?),0x2B (?),0x2C (?),0x2D (?),0x2E (?),0x2F (?),0x30 (?),0x31 (?),0x32 (?),0x33 (?),0x34 (?),0x35 (?),0x36 (?),0x37 (?),0x38 (?),0x39 (?),0x3A (?),0x3B (?),0x3C (?),0x3D (?),0x3E (?),0x3F (?)"
   textline ""
   bitfld.long 0x0   15.          "[ 15 ]     QRIB_EN                             = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   14.          "[ 14 ]     ASYNC_MODE                          = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   13.          "[ 13 ]     CONFIG_TYPE                         = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   12.          "[ 12 ]     CLIENT_PIPELINE_ENABLED             = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   11.          "[ 11 ]     MSA_CHECK_HW_ENABLE                 = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   10.          "[ 10 ]     XPU_SYND_REG_ABSENT                 = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   9.           "[ 9 ]      TZXPU                               = " "0x00 (?),0x01 (?)"
   textline ""
   hexmask.long.byte 0 0.--7. 1   "[7 : 0]    NVMID                               = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00033078$ PER_TESLA9X45_Part5.per -queue XPU_CFG_RPM_CFG_XPU_IDR1"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0003307C
tree " XPU_CFG_RPM_CFG_XPU_REV [R]                                       0x0003307C"
  group.long 0x0--0x3
   textline "POR 0x20060000    MASK = 0xFFFFFFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print XPU_CFG_RPM_CFG_XPU_REV PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   28.--31.     "[31 : 28]  MAJOR                               = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?),0x08 (?),0x09 (?),0x0A (?),0x0B (?),0x0C (?),0x0D (?),0x0E (?),0x0F (?)"
   textline ""
   hexmask.long.word 0 16.--27. 1 "[27 : 16]  MINOR                               = "
   textline ""
   hexmask.long.word 0 0.--15. 1  "[15 : 0]   STEP                                = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0003307C$ PER_TESLA9X45_Part5.per -queue XPU_CFG_RPM_CFG_XPU_REV"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00033200
tree " XPU_CFG_RPM_CFG_XPU_PRT0_RACR0 [RW] (n,m)[(0:0),(0:1)]            0x00033200"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0xFFFFFFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print XPU_CFG_RPM_CFG_XPU_PRT0_RACR0 PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.long 0 0.--31. 1  "[31 : 0]   RE                                  = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00033200$ PER_TESLA9X45_Part5.per -queue XPU_CFG_RPM_CFG_XPU_PRT0_RACR0"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00033204
tree " XPU_CFG_RPM_CFG_XPU_PRT0_RACR1 [RW] (n,m)[(0:0),(0:1)]            0x00033204"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0xFFFFFFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print XPU_CFG_RPM_CFG_XPU_PRT0_RACR1 PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.long 0 0.--31. 1  "[31 : 0]   RE                                  = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00033204$ PER_TESLA9X45_Part5.per -queue XPU_CFG_RPM_CFG_XPU_PRT0_RACR1"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00033220
tree " XPU_CFG_RPM_CFG_XPU_PRT0_WACR0 [RW] (n,m)[(0:0),(0:1)]            0x00033220"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0xFFFFFFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print XPU_CFG_RPM_CFG_XPU_PRT0_WACR0 PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.long 0 0.--31. 1  "[31 : 0]   WE                                  = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00033220$ PER_TESLA9X45_Part5.per -queue XPU_CFG_RPM_CFG_XPU_PRT0_WACR0"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00033224
tree " XPU_CFG_RPM_CFG_XPU_PRT0_WACR1 [RW] (n,m)[(0:0),(0:1)]            0x00033224"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0xFFFFFFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print XPU_CFG_RPM_CFG_XPU_PRT0_WACR1 PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.long 0 0.--31. 1  "[31 : 0]   WE                                  = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00033224$ PER_TESLA9X45_Part5.per -queue XPU_CFG_RPM_CFG_XPU_PRT0_WACR1"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00033240
tree " XPU_CFG_RPM_CFG_XPU_PRT0_START0 [RW] n[1:0]                       0x00033240"
  group.long 0x0--0x3
   textline "POR 0x003FF000    MASK = 0x003FF000    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print XPU_CFG_RPM_CFG_XPU_PRT0_START0 PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.word 0 12.--21. 1 "[21 : 12]  ADDR                                = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00033240$ PER_TESLA9X45_Part5.per -queue XPU_CFG_RPM_CFG_XPU_PRT0_START0"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x000332C0
tree " XPU_CFG_RPM_CFG_XPU_PRT1_START0 [RW] n[1:0]                       0x000332C0"
  group.long 0x0--0x3
   textline "POR 0x003FF000    MASK = 0x003FF000    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print XPU_CFG_RPM_CFG_XPU_PRT1_START0 PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.word 0 12.--21. 1 "[21 : 12]  ADDR                                = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x000332C0$ PER_TESLA9X45_Part5.per -queue XPU_CFG_RPM_CFG_XPU_PRT1_START0"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00033248
tree " XPU_CFG_RPM_CFG_XPU_PRT0_END0 [RW] n[1:0]                         0x00033248"
  group.long 0x0--0x3
   textline "POR 0x003FF000    MASK = 0x003FF000    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print XPU_CFG_RPM_CFG_XPU_PRT0_END0 PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.word 0 12.--21. 1 "[21 : 12]  ADDR                                = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00033248$ PER_TESLA9X45_Part5.per -queue XPU_CFG_RPM_CFG_XPU_PRT0_END0"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x000332C8
tree " XPU_CFG_RPM_CFG_XPU_PRT1_END0 [RW] n[1:0]                         0x000332C8"
  group.long 0x0--0x3
   textline "POR 0x003FF000    MASK = 0x003FF000    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print XPU_CFG_RPM_CFG_XPU_PRT1_END0 PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.word 0 12.--21. 1 "[21 : 12]  ADDR                                = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x000332C8$ PER_TESLA9X45_Part5.per -queue XPU_CFG_RPM_CFG_XPU_PRT1_END0"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00033250
tree " XPU_CFG_RPM_CFG_XPU_PRT0_SCR [RW] n[1:0]                          0x00033250"
  group.long 0x0--0x3
   textline "POR 0x00000001    MASK = 0x0000003F    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print XPU_CFG_RPM_CFG_XPU_PRT0_SCR PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   5.           "[ 5 ]      SCLROE                              = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   4.           "[ 4 ]      VMIDCLROE                           = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   3.           "[ 3 ]      MSACLROE                            = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   2.           "[ 2 ]      VMIDCLRWE                           = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   1.           "[ 1 ]      MSACLRWE                            = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   0.           "[ 0 ]      NS                                  = " "0x00 (?),0x01 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00033250$ PER_TESLA9X45_Part5.per -queue XPU_CFG_RPM_CFG_XPU_PRT0_SCR"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x000332D0
tree " XPU_CFG_RPM_CFG_XPU_PRT1_SCR [RW] n[1:0]                          0x000332D0"
  group.long 0x0--0x3
   textline "POR 0x00000001    MASK = 0x0000003F    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print XPU_CFG_RPM_CFG_XPU_PRT1_SCR PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   5.           "[ 5 ]      SCLROE                              = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   4.           "[ 4 ]      VMIDCLROE                           = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   3.           "[ 3 ]      MSACLROE                            = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   2.           "[ 2 ]      VMIDCLRWE                           = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   1.           "[ 1 ]      MSACLRWE                            = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   0.           "[ 0 ]      NS                                  = " "0x00 (?),0x01 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x000332D0$ PER_TESLA9X45_Part5.per -queue XPU_CFG_RPM_CFG_XPU_PRT1_SCR"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00033254
tree " XPU_CFG_RPM_CFG_XPU_PRT0_MCR [RW] n[1:0]                          0x00033254"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x0000003F    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print XPU_CFG_RPM_CFG_XPU_PRT0_MCR PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   5.           "[ 5 ]      MSACLROE                            = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   4.           "[ 4 ]      VMIDCLROE                           = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   3.           "[ 3 ]      SCLROE                              = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   2.           "[ 2 ]      VMIDCLE                             = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   1.           "[ 1 ]      SCLE                                = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   0.           "[ 0 ]      MSAE                                = " "0x00 (?),0x01 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00033254$ PER_TESLA9X45_Part5.per -queue XPU_CFG_RPM_CFG_XPU_PRT0_MCR"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x000332D4
tree " XPU_CFG_RPM_CFG_XPU_PRT1_MCR [RW] n[1:0]                          0x000332D4"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x0000003F    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print XPU_CFG_RPM_CFG_XPU_PRT1_MCR PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   5.           "[ 5 ]      MSACLROE                            = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   4.           "[ 4 ]      VMIDCLROE                           = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   3.           "[ 3 ]      SCLROE                              = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   2.           "[ 2 ]      VMIDCLE                             = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   1.           "[ 1 ]      SCLE                                = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   0.           "[ 0 ]      MSAE                                = " "0x00 (?),0x01 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x000332D4$ PER_TESLA9X45_Part5.per -queue XPU_CFG_RPM_CFG_XPU_PRT1_MCR"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00033258
tree " XPU_CFG_RPM_CFG_XPU_PRT0_CNTL0 [RW] n[1:0]                        0x00033258"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x80000000    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print XPU_CFG_RPM_CFG_XPU_PRT0_CNTL0 PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   31.          "[ 31 ]     PD                                  = " "0x00 (?),0x01 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00033258$ PER_TESLA9X45_Part5.per -queue XPU_CFG_RPM_CFG_XPU_PRT0_CNTL0"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x000332D8
tree " XPU_CFG_RPM_CFG_XPU_PRT1_CNTL0 [RW] n[1:0]                        0x000332D8"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x80000000    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print XPU_CFG_RPM_CFG_XPU_PRT1_CNTL0 PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   31.          "[ 31 ]     PD                                  = " "0x00 (?),0x01 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x000332D8$ PER_TESLA9X45_Part5.per -queue XPU_CFG_RPM_CFG_XPU_PRT1_CNTL0"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0003325C
tree " XPU_CFG_RPM_CFG_XPU_PRT0_CNTL1 [W] n[1:0]                         0x0003325C"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x00000003    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print XPU_CFG_RPM_CFG_XPU_PRT0_CNTL1 PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   1.           "[ 1 ]      ASRC                                = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   0.           "[ 0 ]      CSRC                                = " "0x00 (?),0x01 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0003325C$ PER_TESLA9X45_Part5.per -queue XPU_CFG_RPM_CFG_XPU_PRT0_CNTL1"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x000332DC
tree " XPU_CFG_RPM_CFG_XPU_PRT1_CNTL1 [W] n[1:0]                         0x000332DC"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x00000003    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print XPU_CFG_RPM_CFG_XPU_PRT1_CNTL1 PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   1.           "[ 1 ]      ASRC                                = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   0.           "[ 0 ]      CSRC                                = " "0x00 (?),0x01 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x000332DC$ PER_TESLA9X45_Part5.per -queue XPU_CFG_RPM_CFG_XPU_PRT1_CNTL1"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0002F000
tree " XPU_CFG_PRNG_CFG_XPU_SCR [RW]                                     0x0002F000"
  group.long 0x0--0x3
   textline "POR 0x00000106    MASK = 0x0000077F    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print XPU_CFG_PRNG_CFG_XPU_SCR PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   10.          "[ 10 ]     SCLEIE                              = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   9.           "[ 9 ]      SCFGEIE                             = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   8.           "[ 8 ]      DYNAMIC_CLK_EN                      = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   6.           "[ 6 ]      NSRGCLEE                            = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   5.           "[ 5 ]      NSCFGE                              = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   4.           "[ 4 ]      SDCDEE                              = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   3.           "[ 3 ]      SEIE                                = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   2.           "[ 2 ]      SCLERE                              = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   1.           "[ 1 ]      SCFGERE                             = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   0.           "[ 0 ]      XPUNSE                              = " "0x00 (?),0x01 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0002F000$ PER_TESLA9X45_Part5.per -queue XPU_CFG_PRNG_CFG_XPU_SCR"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0002F004
tree " XPU_CFG_PRNG_CFG_XPU_SWDR [RW]                                    0x0002F004"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x00000001    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print XPU_CFG_PRNG_CFG_XPU_SWDR PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   0.           "[ 0 ]      SCFGWD                              = " "0x00 (?),0x01 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0002F004$ PER_TESLA9X45_Part5.per -queue XPU_CFG_PRNG_CFG_XPU_SWDR"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0002F040
tree " XPU_CFG_PRNG_CFG_XPU_SEAR0 [R]                                    0x0002F040"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0xFFFFFFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print XPU_CFG_PRNG_CFG_XPU_SEAR0 PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.long 0 0.--31. 1  "[31 : 0]   PA                                  = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0002F040$ PER_TESLA9X45_Part5.per -queue XPU_CFG_PRNG_CFG_XPU_SEAR0"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0002F048
tree " XPU_CFG_PRNG_CFG_XPU_SESR [RW]                                    0x0002F048"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x8000000F    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print XPU_CFG_PRNG_CFG_XPU_SESR PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   31.          "[ 31 ]     MULTI                               = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   3.           "[ 3 ]      CLMULTI                             = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   2.           "[ 2 ]      CFGMULTI                            = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   1.           "[ 1 ]      CLIENT                              = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   0.           "[ 0 ]      CFG                                 = " "0x00 (?),0x01 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0002F048$ PER_TESLA9X45_Part5.per -queue XPU_CFG_PRNG_CFG_XPU_SESR"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0002F04C
tree " XPU_CFG_PRNG_CFG_XPU_SESRRESTORE [RW]                             0x0002F04C"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x8000000F    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print XPU_CFG_PRNG_CFG_XPU_SESRRESTORE PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   31.          "[ 31 ]     MULTI                               = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   3.           "[ 3 ]      CLMULTI                             = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   2.           "[ 2 ]      CFGMULTI                            = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   1.           "[ 1 ]      CLIENT                              = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   0.           "[ 0 ]      CFG                                 = " "0x00 (?),0x01 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0002F04C$ PER_TESLA9X45_Part5.per -queue XPU_CFG_PRNG_CFG_XPU_SESRRESTORE"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0002F050
tree " XPU_CFG_PRNG_CFG_XPU_SESYNR0 [R]                                  0x0002F050"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0xFFFFFFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print XPU_CFG_PRNG_CFG_XPU_SESYNR0 PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.byte 0 24.--31. 1 "[31 : 24]  ATID                                = "
   textline ""
   hexmask.long.byte 0 16.--23. 1 "[23 : 16]  AVMID                               = "
   textline ""
   bitfld.long 0x0   13.--15.     "[15 : 13]  ABID                                = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?)"
   textline ""
   bitfld.long 0x0   8.--12.      "[12 : 8]   APID                                = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?),0x08 (?),0x09 (?),0x0A (?),0x0B (?),0x0C (?),0x0D (?),0x0E (?),0x0F (?),0x10 (?),0x11 (?),0x12 (?),0x13 (?),0x14 (?),0x15 (?),0x16 (?),0x17 (?),0x18 (?),0x19 (?),0x1A (?),0x1B (?),0x1C (?),0x1D (?),0x1E (?),0x1F (?)"
   textline ""
   hexmask.long.byte 0 0.--7. 1   "[7 : 0]    AMID                                = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0002F050$ PER_TESLA9X45_Part5.per -queue XPU_CFG_PRNG_CFG_XPU_SESYNR0"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0002F054
tree " XPU_CFG_PRNG_CFG_XPU_SESYNR1 [R]                                  0x0002F054"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0xFFFFFFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print XPU_CFG_PRNG_CFG_XPU_SESYNR1 PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   31.          "[ 31 ]     DCD                                 = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   30.          "[ 30 ]     AC                                  = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   29.          "[ 29 ]     BURSTLEN                            = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   28.          "[ 28 ]     ARDALLOCATE                         = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   27.          "[ 27 ]     ABURST                              = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   26.          "[ 26 ]     AEXCLUSIVE                          = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   25.          "[ 25 ]     AWRITE                              = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   24.          "[ 24 ]     AFULL                               = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   23.          "[ 23 ]     ARDBEADNDXEN                        = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   22.          "[ 22 ]     AOOO                                = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   19.--21.     "[21 : 19]  APREQPRIORITY                       = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?)"
   textline ""
   bitfld.long 0x0   16.--18.     "[18 : 16]  ASIZE                               = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?)"
   textline ""
   bitfld.long 0x0   15.          "[ 15 ]     AMSSSELFAUTH                        = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   8.--14.      "[14 : 8]   ALEN                                = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?),0x08 (?),0x09 (?),0x0A (?),0x0B (?),0x0C (?),0x0D (?),0x0E (?),0x0F (?),0x10 (?),0x11 (?),0x12 (?),0x13 (?),0x14 (?),0x15 (?),0x16 (?),0x17 (?),0x18 (?),0x19 (?),0x1A (?),0x1B (?),0x1C (?),0x1D (?),0x1E (?),0x1F (?),0x20 (?),0x21 (?),0x22 (?),0x23 (?),0x24 (?),0x25 (?),0x26 (?),0x27 (?),0x28 (?),0x29 (?),0x2A (?),0x2B (?),0x2C (?),0x2D (?),0x2E (?),0x2F (?),0x30 (?),0x31 (?),0x32 (?),0x33 (?),0x34 (?),0x35 (?),0x36 (?),0x37 (?),0x38 (?),0x39 (?),0x3A (?),0x3B (?),0x3C (?),0x3D (?),0x3E (?),0x3F (?),0x40 (?),0x41 (?),0x42 (?),0x43 (?),0x44 (?),0x45 (?),0x46 (?),0x47 (?),0x48 (?),0x49 (?),0x4A (?),0x4B (?),0x4C (?),0x4D (?),0x4E (?),0x4F (?),0x50 (?),0x51 (?),0x52 (?),0x53 (?),0x54 (?),0x55 (?),0x56 (?),0x57 (?),0x58 (?),0x59 (?),0x5A (?),0x5B (?),0x5C (?),0x5D (?),0x5E (?),0x5F (?),0x60 (?),0x61 (?),0x62 (?),0x63 (?),0x64 (?),0x65 (?),0x66 (?),0x67 (?),0x68 (?),0x69 (?),0x6A (?),0x6B (?),0x6C (?),0x6D (?),0x6E (?),0x6F (?),0x70 (?),0x71 (?),0x72 (?),0x73 (?),0x74 (?),0x75 (?),0x76 (?),0x77 (?),0x78 (?),0x79 (?),0x7A (?),0x7B (?),0x7C (?),0x7D (?),0x7E (?),0x7F (?)"
   textline ""
   bitfld.long 0x0   7.           "[ 7 ]      AINST                               = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   6.           "[ 6 ]      APROTNS                             = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   5.           "[ 5 ]      APRIV                               = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   4.           "[ 4 ]      AINNERSHARED                        = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   3.           "[ 3 ]      ASHARED                             = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   0.--2.       "[2 : 0]    AMEMTYPE                            = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0002F054$ PER_TESLA9X45_Part5.per -queue XPU_CFG_PRNG_CFG_XPU_SESYNR1"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0002F058
tree " XPU_CFG_PRNG_CFG_XPU_SESYNR2 [R]                                  0x0002F058"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x00000007    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print XPU_CFG_PRNG_CFG_XPU_SESYNR2 PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   2.           "[ 2 ]      MODEM_PRT_HIT                       = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   1.           "[ 1 ]      SECURE_PRT_HIT                      = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   0.           "[ 0 ]      NONSECURE_PRT_HIT                   = " "0x00 (?),0x01 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0002F058$ PER_TESLA9X45_Part5.per -queue XPU_CFG_PRNG_CFG_XPU_SESYNR2"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0002F100
tree " XPU_CFG_PRNG_CFG_XPU_MCR [RW]                                     0x0002F100"
  group.long 0x0--0x3
   textline "POR 0x00000106    MASK = 0x0000071F    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print XPU_CFG_PRNG_CFG_XPU_MCR PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   10.          "[ 10 ]     CLEIE                               = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   9.           "[ 9 ]      CFGEIE                              = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   8.           "[ 8 ]      DYNAMIC_CLK_EN                      = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   4.           "[ 4 ]      DCDEE                               = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   3.           "[ 3 ]      EIE                                 = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   2.           "[ 2 ]      CLERE                               = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   1.           "[ 1 ]      CFGERE                              = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   0.           "[ 0 ]      XPUMSAE                             = " "0x00 (?),0x01 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0002F100$ PER_TESLA9X45_Part5.per -queue XPU_CFG_PRNG_CFG_XPU_MCR"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0002F140
tree " XPU_CFG_PRNG_CFG_XPU_MEAR0 [R]                                    0x0002F140"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0xFFFFFFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print XPU_CFG_PRNG_CFG_XPU_MEAR0 PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.long 0 0.--31. 1  "[31 : 0]   PA                                  = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0002F140$ PER_TESLA9X45_Part5.per -queue XPU_CFG_PRNG_CFG_XPU_MEAR0"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0002F148
tree " XPU_CFG_PRNG_CFG_XPU_MESR [RW]                                    0x0002F148"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x8000000F    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print XPU_CFG_PRNG_CFG_XPU_MESR PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   31.          "[ 31 ]     MULTI                               = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   3.           "[ 3 ]      CLMULTI                             = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   2.           "[ 2 ]      CFGMULTI                            = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   1.           "[ 1 ]      CLIENT                              = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   0.           "[ 0 ]      CFG                                 = " "0x00 (?),0x01 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0002F148$ PER_TESLA9X45_Part5.per -queue XPU_CFG_PRNG_CFG_XPU_MESR"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0002F14C
tree " XPU_CFG_PRNG_CFG_XPU_MESRRESTORE [RW]                             0x0002F14C"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x8000000F    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print XPU_CFG_PRNG_CFG_XPU_MESRRESTORE PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   31.          "[ 31 ]     MULTI                               = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   3.           "[ 3 ]      CLMULTI                             = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   2.           "[ 2 ]      CFGMULTI                            = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   1.           "[ 1 ]      CLIENT                              = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   0.           "[ 0 ]      CFG                                 = " "0x00 (?),0x01 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0002F14C$ PER_TESLA9X45_Part5.per -queue XPU_CFG_PRNG_CFG_XPU_MESRRESTORE"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0002F150
tree " XPU_CFG_PRNG_CFG_XPU_MESYNR0 [R]                                  0x0002F150"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0xFFFFFFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print XPU_CFG_PRNG_CFG_XPU_MESYNR0 PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.byte 0 24.--31. 1 "[31 : 24]  ATID                                = "
   textline ""
   hexmask.long.byte 0 16.--23. 1 "[23 : 16]  AVMID                               = "
   textline ""
   bitfld.long 0x0   13.--15.     "[15 : 13]  ABID                                = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?)"
   textline ""
   bitfld.long 0x0   8.--12.      "[12 : 8]   APID                                = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?),0x08 (?),0x09 (?),0x0A (?),0x0B (?),0x0C (?),0x0D (?),0x0E (?),0x0F (?),0x10 (?),0x11 (?),0x12 (?),0x13 (?),0x14 (?),0x15 (?),0x16 (?),0x17 (?),0x18 (?),0x19 (?),0x1A (?),0x1B (?),0x1C (?),0x1D (?),0x1E (?),0x1F (?)"
   textline ""
   hexmask.long.byte 0 0.--7. 1   "[7 : 0]    AMID                                = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0002F150$ PER_TESLA9X45_Part5.per -queue XPU_CFG_PRNG_CFG_XPU_MESYNR0"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0002F154
tree " XPU_CFG_PRNG_CFG_XPU_MESYNR1 [R]                                  0x0002F154"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0xFFFFFFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print XPU_CFG_PRNG_CFG_XPU_MESYNR1 PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   31.          "[ 31 ]     DCD                                 = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   30.          "[ 30 ]     AC                                  = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   29.          "[ 29 ]     BURSTLEN                            = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   28.          "[ 28 ]     ARDALLOCATE                         = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   27.          "[ 27 ]     ABURST                              = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   26.          "[ 26 ]     AEXCLUSIVE                          = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   25.          "[ 25 ]     AWRITE                              = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   24.          "[ 24 ]     AFULL                               = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   23.          "[ 23 ]     ARDBEADNDXEN                        = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   22.          "[ 22 ]     AOOO                                = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   19.--21.     "[21 : 19]  APREQPRIORITY                       = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?)"
   textline ""
   bitfld.long 0x0   16.--18.     "[18 : 16]  ASIZE                               = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?)"
   textline ""
   bitfld.long 0x0   15.          "[ 15 ]     AMSSSELFAUTH                        = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   8.--14.      "[14 : 8]   ALEN                                = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?),0x08 (?),0x09 (?),0x0A (?),0x0B (?),0x0C (?),0x0D (?),0x0E (?),0x0F (?),0x10 (?),0x11 (?),0x12 (?),0x13 (?),0x14 (?),0x15 (?),0x16 (?),0x17 (?),0x18 (?),0x19 (?),0x1A (?),0x1B (?),0x1C (?),0x1D (?),0x1E (?),0x1F (?),0x20 (?),0x21 (?),0x22 (?),0x23 (?),0x24 (?),0x25 (?),0x26 (?),0x27 (?),0x28 (?),0x29 (?),0x2A (?),0x2B (?),0x2C (?),0x2D (?),0x2E (?),0x2F (?),0x30 (?),0x31 (?),0x32 (?),0x33 (?),0x34 (?),0x35 (?),0x36 (?),0x37 (?),0x38 (?),0x39 (?),0x3A (?),0x3B (?),0x3C (?),0x3D (?),0x3E (?),0x3F (?),0x40 (?),0x41 (?),0x42 (?),0x43 (?),0x44 (?),0x45 (?),0x46 (?),0x47 (?),0x48 (?),0x49 (?),0x4A (?),0x4B (?),0x4C (?),0x4D (?),0x4E (?),0x4F (?),0x50 (?),0x51 (?),0x52 (?),0x53 (?),0x54 (?),0x55 (?),0x56 (?),0x57 (?),0x58 (?),0x59 (?),0x5A (?),0x5B (?),0x5C (?),0x5D (?),0x5E (?),0x5F (?),0x60 (?),0x61 (?),0x62 (?),0x63 (?),0x64 (?),0x65 (?),0x66 (?),0x67 (?),0x68 (?),0x69 (?),0x6A (?),0x6B (?),0x6C (?),0x6D (?),0x6E (?),0x6F (?),0x70 (?),0x71 (?),0x72 (?),0x73 (?),0x74 (?),0x75 (?),0x76 (?),0x77 (?),0x78 (?),0x79 (?),0x7A (?),0x7B (?),0x7C (?),0x7D (?),0x7E (?),0x7F (?)"
   textline ""
   bitfld.long 0x0   7.           "[ 7 ]      AINST                               = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   6.           "[ 6 ]      APROTNS                             = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   5.           "[ 5 ]      APRIV                               = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   4.           "[ 4 ]      AINNERSHARED                        = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   3.           "[ 3 ]      ASHARED                             = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   0.--2.       "[2 : 0]    AMEMTYPE                            = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0002F154$ PER_TESLA9X45_Part5.per -queue XPU_CFG_PRNG_CFG_XPU_MESYNR1"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0002F158
tree " XPU_CFG_PRNG_CFG_XPU_MESYNR2 [R]                                  0x0002F158"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x00000007    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print XPU_CFG_PRNG_CFG_XPU_MESYNR2 PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   2.           "[ 2 ]      MODEM_PRT_HIT                       = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   1.           "[ 1 ]      SECURE_PRT_HIT                      = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   0.           "[ 0 ]      NONSECURE_PRT_HIT                   = " "0x00 (?),0x01 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0002F158$ PER_TESLA9X45_Part5.per -queue XPU_CFG_PRNG_CFG_XPU_MESYNR2"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0002F080
tree " XPU_CFG_PRNG_CFG_XPU_CR [RW]                                      0x0002F080"
  group.long 0x0--0x3
   textline "POR 0x00000106    MASK = 0x0001071F    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print XPU_CFG_PRNG_CFG_XPU_CR PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   16.          "[ 16 ]     MSAE                                = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   10.          "[ 10 ]     CLEIE                               = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   9.           "[ 9 ]      CFGEIE                              = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   8.           "[ 8 ]      DYNAMIC_CLK_EN                      = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   4.           "[ 4 ]      DCDEE                               = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   3.           "[ 3 ]      EIE                                 = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   2.           "[ 2 ]      CLERE                               = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   1.           "[ 1 ]      CFGERE                              = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   0.           "[ 0 ]      XPUVMIDE                            = " "0x00 (?),0x01 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0002F080$ PER_TESLA9X45_Part5.per -queue XPU_CFG_PRNG_CFG_XPU_CR"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0002F0A0
tree " XPU_CFG_PRNG_CFG_XPU_RPU_ACR0 [RW] n[0:0]                         0x0002F0A0"
  group.long 0x0--0x3
   textline "POR 0xFFFFFFFF    MASK = 0xFFFFFFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print XPU_CFG_PRNG_CFG_XPU_RPU_ACR0 PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.long 0 0.--31. 1  "[31 : 0]   RWE                                 = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0002F0A0$ PER_TESLA9X45_Part5.per -queue XPU_CFG_PRNG_CFG_XPU_RPU_ACR0"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0002F0C0
tree " XPU_CFG_PRNG_CFG_XPU_EAR0 [R]                                     0x0002F0C0"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0xFFFFFFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print XPU_CFG_PRNG_CFG_XPU_EAR0 PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.long 0 0.--31. 1  "[31 : 0]   PA                                  = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0002F0C0$ PER_TESLA9X45_Part5.per -queue XPU_CFG_PRNG_CFG_XPU_EAR0"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0002F0C8
tree " XPU_CFG_PRNG_CFG_XPU_ESR [RW]                                     0x0002F0C8"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x8000000F    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print XPU_CFG_PRNG_CFG_XPU_ESR PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   31.          "[ 31 ]     MULTI                               = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   3.           "[ 3 ]      CLMULTI                             = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   2.           "[ 2 ]      CFGMULTI                            = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   1.           "[ 1 ]      CLIENT                              = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   0.           "[ 0 ]      CFG                                 = " "0x00 (?),0x01 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0002F0C8$ PER_TESLA9X45_Part5.per -queue XPU_CFG_PRNG_CFG_XPU_ESR"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0002F0CC
tree " XPU_CFG_PRNG_CFG_XPU_ESRRESTORE [RW]                              0x0002F0CC"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x8000000F    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print XPU_CFG_PRNG_CFG_XPU_ESRRESTORE PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   31.          "[ 31 ]     MULTI                               = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   3.           "[ 3 ]      CLMULTI                             = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   2.           "[ 2 ]      CFGMULTI                            = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   1.           "[ 1 ]      CLIENT                              = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   0.           "[ 0 ]      CFG                                 = " "0x00 (?),0x01 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0002F0CC$ PER_TESLA9X45_Part5.per -queue XPU_CFG_PRNG_CFG_XPU_ESRRESTORE"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0002F0D0
tree " XPU_CFG_PRNG_CFG_XPU_ESYNR0 [R]                                   0x0002F0D0"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0xFFFFFFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print XPU_CFG_PRNG_CFG_XPU_ESYNR0 PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.byte 0 24.--31. 1 "[31 : 24]  ATID                                = "
   textline ""
   hexmask.long.byte 0 16.--23. 1 "[23 : 16]  AVMID                               = "
   textline ""
   bitfld.long 0x0   13.--15.     "[15 : 13]  ABID                                = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?)"
   textline ""
   bitfld.long 0x0   8.--12.      "[12 : 8]   APID                                = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?),0x08 (?),0x09 (?),0x0A (?),0x0B (?),0x0C (?),0x0D (?),0x0E (?),0x0F (?),0x10 (?),0x11 (?),0x12 (?),0x13 (?),0x14 (?),0x15 (?),0x16 (?),0x17 (?),0x18 (?),0x19 (?),0x1A (?),0x1B (?),0x1C (?),0x1D (?),0x1E (?),0x1F (?)"
   textline ""
   hexmask.long.byte 0 0.--7. 1   "[7 : 0]    AMID                                = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0002F0D0$ PER_TESLA9X45_Part5.per -queue XPU_CFG_PRNG_CFG_XPU_ESYNR0"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0002F0D4
tree " XPU_CFG_PRNG_CFG_XPU_ESYNR1 [R]                                   0x0002F0D4"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0xFFFFFFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print XPU_CFG_PRNG_CFG_XPU_ESYNR1 PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   31.          "[ 31 ]     DCD                                 = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   30.          "[ 30 ]     AC                                  = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   29.          "[ 29 ]     BURSTLEN                            = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   28.          "[ 28 ]     ARDALLOCATE                         = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   27.          "[ 27 ]     ABURST                              = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   26.          "[ 26 ]     AEXCLUSIVE                          = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   25.          "[ 25 ]     AWRITE                              = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   24.          "[ 24 ]     AFULL                               = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   23.          "[ 23 ]     ARDBEADNDXEN                        = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   22.          "[ 22 ]     AOOO                                = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   19.--21.     "[21 : 19]  APREQPRIORITY                       = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?)"
   textline ""
   bitfld.long 0x0   16.--18.     "[18 : 16]  ASIZE                               = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?)"
   textline ""
   bitfld.long 0x0   15.          "[ 15 ]     AMSSSELFAUTH                        = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   8.--14.      "[14 : 8]   ALEN                                = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?),0x08 (?),0x09 (?),0x0A (?),0x0B (?),0x0C (?),0x0D (?),0x0E (?),0x0F (?),0x10 (?),0x11 (?),0x12 (?),0x13 (?),0x14 (?),0x15 (?),0x16 (?),0x17 (?),0x18 (?),0x19 (?),0x1A (?),0x1B (?),0x1C (?),0x1D (?),0x1E (?),0x1F (?),0x20 (?),0x21 (?),0x22 (?),0x23 (?),0x24 (?),0x25 (?),0x26 (?),0x27 (?),0x28 (?),0x29 (?),0x2A (?),0x2B (?),0x2C (?),0x2D (?),0x2E (?),0x2F (?),0x30 (?),0x31 (?),0x32 (?),0x33 (?),0x34 (?),0x35 (?),0x36 (?),0x37 (?),0x38 (?),0x39 (?),0x3A (?),0x3B (?),0x3C (?),0x3D (?),0x3E (?),0x3F (?),0x40 (?),0x41 (?),0x42 (?),0x43 (?),0x44 (?),0x45 (?),0x46 (?),0x47 (?),0x48 (?),0x49 (?),0x4A (?),0x4B (?),0x4C (?),0x4D (?),0x4E (?),0x4F (?),0x50 (?),0x51 (?),0x52 (?),0x53 (?),0x54 (?),0x55 (?),0x56 (?),0x57 (?),0x58 (?),0x59 (?),0x5A (?),0x5B (?),0x5C (?),0x5D (?),0x5E (?),0x5F (?),0x60 (?),0x61 (?),0x62 (?),0x63 (?),0x64 (?),0x65 (?),0x66 (?),0x67 (?),0x68 (?),0x69 (?),0x6A (?),0x6B (?),0x6C (?),0x6D (?),0x6E (?),0x6F (?),0x70 (?),0x71 (?),0x72 (?),0x73 (?),0x74 (?),0x75 (?),0x76 (?),0x77 (?),0x78 (?),0x79 (?),0x7A (?),0x7B (?),0x7C (?),0x7D (?),0x7E (?),0x7F (?)"
   textline ""
   bitfld.long 0x0   7.           "[ 7 ]      AINST                               = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   6.           "[ 6 ]      APROTNS                             = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   5.           "[ 5 ]      APRIV                               = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   4.           "[ 4 ]      AINNERSHARED                        = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   3.           "[ 3 ]      ASHARED                             = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   0.--2.       "[2 : 0]    AMEMTYPE                            = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0002F0D4$ PER_TESLA9X45_Part5.per -queue XPU_CFG_PRNG_CFG_XPU_ESYNR1"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0002F0D8
tree " XPU_CFG_PRNG_CFG_XPU_ESYNR2 [R]                                   0x0002F0D8"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x00000007    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print XPU_CFG_PRNG_CFG_XPU_ESYNR2 PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   2.           "[ 2 ]      MODEM_PRT_HIT                       = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   1.           "[ 1 ]      SECURE_PRT_HIT                      = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   0.           "[ 0 ]      NONSECURE_PRT_HIT                   = " "0x00 (?),0x01 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0002F0D8$ PER_TESLA9X45_Part5.per -queue XPU_CFG_PRNG_CFG_XPU_ESYNR2"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0002F074
tree " XPU_CFG_PRNG_CFG_XPU_IDR0 [R]                                     0x0002F074"
  group.long 0x0--0x3
   textline "POR 0x00001C00    MASK = 0xC000BFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print XPU_CFG_PRNG_CFG_XPU_IDR0 PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   31.          "[ 31 ]     CLIENTREQ_HALT_ACK_HW_EN            = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   30.          "[ 30 ]     SAVERESTORE_HW_EN                   = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   15.          "[ 15 ]     BLED                                = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   12.--13.     "[13 : 12]  XPUT                                = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?)"
   textline ""
   bitfld.long 0x0   11.          "[ 11 ]     PT                                  = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   10.          "[ 10 ]     MV                                  = " "0x00 (?),0x01 (?)"
   textline ""
   hexmask.long.word 0 0.--9. 1   "[9 : 0]    NRG                                 = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0002F074$ PER_TESLA9X45_Part5.per -queue XPU_CFG_PRNG_CFG_XPU_IDR0"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0002F078
tree " XPU_CFG_PRNG_CFG_XPU_IDR1 [R]                                     0x0002F078"
  group.long 0x0--0x3
   textline "POR 0x1F090A1F    MASK = 0x7F3FFEFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print XPU_CFG_PRNG_CFG_XPU_IDR1 PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   30.          "[ 30 ]     AMT_HW_ENABLE                       = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   24.--29.     "[29 : 24]  CLIENT_ADDR_WIDTH                   = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?),0x08 (?),0x09 (?),0x0A (?),0x0B (?),0x0C (?),0x0D (?),0x0E (?),0x0F (?),0x10 (?),0x11 (?),0x12 (?),0x13 (?),0x14 (?),0x15 (?),0x16 (?),0x17 (?),0x18 (?),0x19 (?),0x1A (?),0x1B (?),0x1C (?),0x1D (?),0x1E (?),0x1F (?),0x20 (?),0x21 (?),0x22 (?),0x23 (?),0x24 (?),0x25 (?),0x26 (?),0x27 (?),0x28 (?),0x29 (?),0x2A (?),0x2B (?),0x2C (?),0x2D (?),0x2E (?),0x2F (?),0x30 (?),0x31 (?),0x32 (?),0x33 (?),0x34 (?),0x35 (?),0x36 (?),0x37 (?),0x38 (?),0x39 (?),0x3A (?),0x3B (?),0x3C (?),0x3D (?),0x3E (?),0x3F (?)"
   textline ""
   bitfld.long 0x0   16.--21.     "[21 : 16]  CONFIG_ADDR_WIDTH                   = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?),0x08 (?),0x09 (?),0x0A (?),0x0B (?),0x0C (?),0x0D (?),0x0E (?),0x0F (?),0x10 (?),0x11 (?),0x12 (?),0x13 (?),0x14 (?),0x15 (?),0x16 (?),0x17 (?),0x18 (?),0x19 (?),0x1A (?),0x1B (?),0x1C (?),0x1D (?),0x1E (?),0x1F (?),0x20 (?),0x21 (?),0x22 (?),0x23 (?),0x24 (?),0x25 (?),0x26 (?),0x27 (?),0x28 (?),0x29 (?),0x2A (?),0x2B (?),0x2C (?),0x2D (?),0x2E (?),0x2F (?),0x30 (?),0x31 (?),0x32 (?),0x33 (?),0x34 (?),0x35 (?),0x36 (?),0x37 (?),0x38 (?),0x39 (?),0x3A (?),0x3B (?),0x3C (?),0x3D (?),0x3E (?),0x3F (?)"
   textline ""
   bitfld.long 0x0   15.          "[ 15 ]     QRIB_EN                             = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   14.          "[ 14 ]     ASYNC_MODE                          = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   13.          "[ 13 ]     CONFIG_TYPE                         = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   12.          "[ 12 ]     CLIENT_PIPELINE_ENABLED             = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   11.          "[ 11 ]     MSA_CHECK_HW_ENABLE                 = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   10.          "[ 10 ]     XPU_SYND_REG_ABSENT                 = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   9.           "[ 9 ]      TZXPU                               = " "0x00 (?),0x01 (?)"
   textline ""
   hexmask.long.byte 0 0.--7. 1   "[7 : 0]    NVMID                               = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0002F078$ PER_TESLA9X45_Part5.per -queue XPU_CFG_PRNG_CFG_XPU_IDR1"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0002F07C
tree " XPU_CFG_PRNG_CFG_XPU_REV [R]                                      0x0002F07C"
  group.long 0x0--0x3
   textline "POR 0x20060000    MASK = 0xFFFFFFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print XPU_CFG_PRNG_CFG_XPU_REV PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   28.--31.     "[31 : 28]  MAJOR                               = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?),0x08 (?),0x09 (?),0x0A (?),0x0B (?),0x0C (?),0x0D (?),0x0E (?),0x0F (?)"
   textline ""
   hexmask.long.word 0 16.--27. 1 "[27 : 16]  MINOR                               = "
   textline ""
   hexmask.long.word 0 0.--15. 1  "[15 : 0]   STEP                                = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0002F07C$ PER_TESLA9X45_Part5.per -queue XPU_CFG_PRNG_CFG_XPU_REV"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0002F200
tree " XPU_CFG_PRNG_CFG_XPU_RG0_RACR0 [RW] (n,m)[(0:0),(0:0)]            0x0002F200"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0xFFFFFFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print XPU_CFG_PRNG_CFG_XPU_RG0_RACR0 PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.long 0 0.--31. 1  "[31 : 0]   RE                                  = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0002F200$ PER_TESLA9X45_Part5.per -queue XPU_CFG_PRNG_CFG_XPU_RG0_RACR0"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0002F220
tree " XPU_CFG_PRNG_CFG_XPU_RG0_WACR0 [RW] (n,m)[(0:0),(0:0)]            0x0002F220"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0xFFFFFFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print XPU_CFG_PRNG_CFG_XPU_RG0_WACR0 PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.long 0 0.--31. 1  "[31 : 0]   WE                                  = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0002F220$ PER_TESLA9X45_Part5.per -queue XPU_CFG_PRNG_CFG_XPU_RG0_WACR0"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0002F250
tree " XPU_CFG_PRNG_CFG_XPU_RG0_SCR [RW] n[0:0]                          0x0002F250"
  group.long 0x0--0x3
   textline "POR 0x00000001    MASK = 0x0000003F    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print XPU_CFG_PRNG_CFG_XPU_RG0_SCR PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   5.           "[ 5 ]      SCLROE                              = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   4.           "[ 4 ]      VMIDCLROE                           = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   3.           "[ 3 ]      MSACLROE                            = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   2.           "[ 2 ]      VMIDCLRWE                           = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   1.           "[ 1 ]      MSACLRWE                            = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   0.           "[ 0 ]      NS                                  = " "0x00 (?),0x01 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0002F250$ PER_TESLA9X45_Part5.per -queue XPU_CFG_PRNG_CFG_XPU_RG0_SCR"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0002F254
tree " XPU_CFG_PRNG_CFG_XPU_RG0_MCR [RW] n[0:0]                          0x0002F254"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x0000003F    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print XPU_CFG_PRNG_CFG_XPU_RG0_MCR PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   5.           "[ 5 ]      MSACLROE                            = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   4.           "[ 4 ]      VMIDCLROE                           = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   3.           "[ 3 ]      SCLROE                              = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   2.           "[ 2 ]      VMIDCLE                             = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   1.           "[ 1 ]      SCLE                                = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   0.           "[ 0 ]      MSAE                                = " "0x00 (?),0x01 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0002F254$ PER_TESLA9X45_Part5.per -queue XPU_CFG_PRNG_CFG_XPU_RG0_MCR"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00022000
tree " PRNG_PRNG_DATA_OUT [R]                                            0x00022000"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0xFFFFFFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print PRNG_PRNG_DATA_OUT PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.long 0 0.--31. 1  "[31 : 0]   PRNG_DATA_OUT                       = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00022000$ PER_TESLA9X45_Part5.per -queue PRNG_PRNG_DATA_OUT"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00022004
tree " PRNG_PRNG_STATUS [R]                                              0x00022004"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x000003FF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print PRNG_PRNG_STATUS PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   8.--9.       "[9 : 8]    CURRENT_OPERATION                   = " "0x00 (IDLE),0x01 (GENERATE),0x02 (INSTANTIATE),0x03 (RESEED)"
   textline ""
   bitfld.long 0x0   7.           "[ 7 ]      GENERATE_REQUIRED                   = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   6.           "[ 6 ]      RESEED_REQUIRED                     = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   5.           "[ 5 ]      INSTANTIATE_REQUIRED                = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   4.           "[ 4 ]      RING_OSC3_HEALTHY                   = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   3.           "[ 3 ]      RING_OSC2_HEALTHY                   = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   2.           "[ 2 ]      RING_OSC1_HEALTHY                   = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   1.           "[ 1 ]      RING_OSC0_HEALTHY                   = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   0.           "[ 0 ]      DATA_AVAIL                          = " "0x00 (?),0x01 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00022004$ PER_TESLA9X45_Part5.per -queue PRNG_PRNG_STATUS"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00022008
tree " PRNG_PRNG_HW_VERSION [R]                                          0x00022008"
  group.long 0x0--0x3
   textline "POR 0x00010001    MASK = 0xFFFFFFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print PRNG_PRNG_HW_VERSION PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.word 0 16.--31. 1 "[31 : 16]  MAJOR_VERSION                       = "
   textline ""
   hexmask.long.byte 0 8.--15. 1  "[15 : 8]   MINOR_VERSION                       = "
   textline ""
   hexmask.long.byte 0 0.--7. 1   "[7 : 0]    STEP                                = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00022008$ PER_TESLA9X45_Part5.per -queue PRNG_PRNG_HW_VERSION"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00022010
tree " PRNG_PRNG_ENTROPY_CNTR [R]                                        0x00022010"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0xFFFFFFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print PRNG_PRNG_ENTROPY_CNTR PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.long 0 0.--31. 1  "[31 : 0]   ENTROPY_CNTR                        = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00022010$ PER_TESLA9X45_Part5.per -queue PRNG_PRNG_ENTROPY_CNTR"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00022014
tree " PRNG_PRNG_SAMPLE_CNTR [R]                                         0x00022014"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0xFFFFFFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print PRNG_PRNG_SAMPLE_CNTR PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.long 0 0.--31. 1  "[31 : 0]   SAMPLE_CNTR                         = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00022014$ PER_TESLA9X45_Part5.per -queue PRNG_PRNG_SAMPLE_CNTR"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00022018
tree " PRNG_PRNG_GEN_CNTR [R]                                            0x00022018"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0xFFFFFFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print PRNG_PRNG_GEN_CNTR PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.long 0 0.--31. 1  "[31 : 0]   PRNG_GEN_CNTR                       = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00022018$ PER_TESLA9X45_Part5.per -queue PRNG_PRNG_GEN_CNTR"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0002201C
tree " PRNG_PRNG_RESEED_CNTR [R]                                         0x0002201C"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0xFFFFFFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print PRNG_PRNG_RESEED_CNTR PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.long 0 0.--31. 1  "[31 : 0]   RESEED_CNTR                         = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0002201C$ PER_TESLA9X45_Part5.per -queue PRNG_PRNG_RESEED_CNTR"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00022020
tree " PRNG_PRNG_INSTANTIATE_CNTR [R]                                    0x00022020"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0xFFFFFFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print PRNG_PRNG_INSTANTIATE_CNTR PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.long 0 0.--31. 1  "[31 : 0]   INSTANTIATE_CNTR                    = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00022020$ PER_TESLA9X45_Part5.per -queue PRNG_PRNG_INSTANTIATE_CNTR"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00022024
tree " PRNG_PRNG_DEBUG [R]                                               0x00022024"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x00003FFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print PRNG_PRNG_DEBUG PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   10.--13.     "[13 : 10]  RNG_STATE                           = " "0x00 (IDLE),0x01 (ENABLE_HASHGEN),0x02 (ENABLE_HASH_DF_H),0x03 (UPDATE_V),0x04 (ENABLE_HASH_DF_V),0x05 (POP_STATE_COLLECTOR_V),0x06 (ENABLE_HASH_DF_C),0x07 (POP_STATE_COLLECTOR_C),0x08 (?),0x09 (?),0x0A (?),0x0B (?),0x0C (?),0x0D (?),0x0E (?),0x0F (?)"
   textline ""
   bitfld.long 0x0   7.--9.       "[9 : 7]    HASHGEN_STATE                       = " "0x00 (IDLE),0x01 (INITIALIZE),0x02 (WAIT_SHA_DONE),0x03 (UPDATE_LOCAL_V),0x04 (?),0x05 (?),0x06 (?),0x07 (?)"
   textline ""
   bitfld.long 0x0   4.--6.       "[6 : 4]    HASH_DF_STATE                       = " "0x00 (IDLE),0x01 (INITIALIZE),0x02 (WAIT_IDLE),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?)"
   textline ""
   bitfld.long 0x0   0.--3.       "[3 : 0]    PAD_STATE                           = " "0x00 (IDLE),0x01 (PERSONALIZATION_STRING),0x02 (LOAD_ENTROPY),0x03 (INSERT_V),0x04 (LOAD_STEP_ID),0x05 (LOAD_NUM_BITS),0x06 (LOAD_CNTR_VAL),0x07 (UPDATE_HASHCNT),0x08 (PAD_FIRST),0x09 (PAD_ZEROES),0x0A (PAD_LENGTH_1),0x0B (PAD_LENGTH_0),0x0C (WAIT_SHA_DONE),0x0D (?),0x0E (?),0x0F (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00022024$ PER_TESLA9X45_Part5.per -queue PRNG_PRNG_DEBUG"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00022100
tree " PRNG_PRNG_LFSR_CFG [RW]                                           0x00022100"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x0001FFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print PRNG_PRNG_LFSR_CFG PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   16.          "[ 16 ]     LFSR_OVRID_ON                       = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   15.          "[ 15 ]     LFSR3_EN                            = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   12.--14.     "[14 : 12]  RING_OSC3_CFG                       = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (FEEDBACK_POINT_0),0x05 (FEEDBACK_POINT_1),0x06 (FEEDBACK_POINT_2),0x07 (FEEDBACK_POINT_3)"
   textline ""
   bitfld.long 0x0   11.          "[ 11 ]     LFSR2_EN                            = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   8.--10.      "[10 : 8]   RING_OSC2_CFG                       = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (FEEDBACK_POINT_0),0x05 (FEEDBACK_POINT_1),0x06 (FEEDBACK_POINT_2),0x07 (FEEDBACK_POINT_3)"
   textline ""
   bitfld.long 0x0   7.           "[ 7 ]      LFSR1_EN                            = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   4.--6.       "[6 : 4]    RING_OSC1_CFG                       = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (FEEDBACK_POINT_0),0x05 (FEEDBACK_POINT_1),0x06 (FEEDBACK_POINT_2),0x07 (FEEDBACK_POINT_3)"
   textline ""
   bitfld.long 0x0   3.           "[ 3 ]      LFSR0_EN                            = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   0.--2.       "[2 : 0]    RING_OSC0_CFG                       = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (FEEDBACK_POINT_0),0x05 (FEEDBACK_POINT_1),0x06 (FEEDBACK_POINT_2),0x07 (FEEDBACK_POINT_3)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00022100$ PER_TESLA9X45_Part5.per -queue PRNG_PRNG_LFSR_CFG"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00022104
tree " PRNG_PRNG_CONFIG [RW]                                             0x00022104"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x0000003F    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print PRNG_PRNG_CONFIG PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   2.--5.       "[5 : 2]    TEST_OUT_SEL                        = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?),0x08 (ROSC0_DIV_32),0x09 (ROSC1_DIV_32),0x0A (ROSC2_DIV_32),0x0B (ROSC3_DIV_32),0x0C (ROSC0_SAMP),0x0D (ROSC1_SAMP),0x0E (ROSC2_SAMP),0x0F (ROSC3_SAMP)"
   textline ""
   bitfld.long 0x0   1.           "[ 1 ]      PRNG_EN                             = " "0x00 (DISABLED),0x01 (ENABLED)"
   textline ""
   bitfld.long 0x0   0.           "[ 0 ]      SW_RESET                            = " "0x00 (?),0x01 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00022104$ PER_TESLA9X45_Part5.per -queue PRNG_PRNG_CONFIG"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00022108
tree " PRNG_PRNG_PERSONALIZATION_STRING [RW]                             0x00022108"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0xFFFFFFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print PRNG_PRNG_PERSONALIZATION_STRING PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.long 0 0.--31. 1  "[31 : 0]   PERSONALIZATION_STRING              = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00022108$ PER_TESLA9X45_Part5.per -queue PRNG_PRNG_PERSONALIZATION_STRING"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00022110
tree " PRNG_PRNG_NUM_ENTROPY [RW]                                        0x00022110"
  group.long 0x0--0x3
   textline "POR 0x00000400    MASK = 0xFFFFFFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print PRNG_PRNG_NUM_ENTROPY PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.long 0 0.--31. 1  "[31 : 0]   NUM_ENTROPY_BYTES                   = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00022110$ PER_TESLA9X45_Part5.per -queue PRNG_PRNG_NUM_ENTROPY"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00022114
tree " PRNG_PRNG_SAMPLE_FREQ [RW]                                        0x00022114"
  group.long 0x0--0x3
   textline "POR 0x00000400    MASK = 0xFFFFFFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print PRNG_PRNG_SAMPLE_FREQ PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.long 0 0.--31. 1  "[31 : 0]   SAMPLE_FREQ                         = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00022114$ PER_TESLA9X45_Part5.per -queue PRNG_PRNG_SAMPLE_FREQ"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00022118
tree " PRNG_PRNG_GEN_WORDS [RW]                                          0x00022118"
  group.long 0x0--0x3
   textline "POR 0x00000008    MASK = 0xFFFFFFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print PRNG_PRNG_GEN_WORDS PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.long 0 0.--31. 1  "[31 : 0]   REQUESTED_WORDS                     = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00022118$ PER_TESLA9X45_Part5.per -queue PRNG_PRNG_GEN_WORDS"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0002211C
tree " PRNG_PRNG_RESEED_FREQ [RW]                                        0x0002211C"
  group.long 0x0--0x3
   textline "POR 0x00010000    MASK = 0xFFFFFFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print PRNG_PRNG_RESEED_FREQ PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.long 0 0.--31. 1  "[31 : 0]   RESEED_FREQ                         = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0002211C$ PER_TESLA9X45_Part5.per -queue PRNG_PRNG_RESEED_FREQ"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00022120
tree " PRNG_PRNG_INSTANTIATE_FREQ [RW]                                   0x00022120"
  group.long 0x0--0x3
   textline "POR 0x00010000    MASK = 0xFFFFFFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print PRNG_PRNG_INSTANTIATE_FREQ PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.long 0 0.--31. 1  "[31 : 0]   INSTANTIATE_FREQ                    = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00022120$ PER_TESLA9X45_Part5.per -queue PRNG_PRNG_INSTANTIATE_FREQ"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

