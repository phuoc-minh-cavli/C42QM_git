  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x0000003F    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print PCNOC_TPRB0_SPROF_COUNTERS_5_SRC PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   5.           "[ 5 ]      EXTEVENT                            = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   0.--4.       "[4 : 0]    INTEVENT                            = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?),0x08 (?),0x09 (?),0x0A (?),0x0B (?),0x0C (?),0x0D (?),0x0E (?),0x0F (?),0x10 (?),0x11 (?),0x12 (?),0x13 (?),0x14 (?),0x15 (?),0x16 (?),0x17 (?),0x18 (?),0x19 (?),0x1A (?),0x1B (?),0x1C (?),0x1D (?),0x1E (?),0x1F (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0050419C$ PER_TESLA9X45_Part5.per -queue PCNOC_TPRB0_SPROF_COUNTERS_5_SRC"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x005041A0
tree " PCNOC_TPRB0_SPROF_COUNTERS_5_ALARMMODE [RW]                       0x005041A0"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x00000003    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print PCNOC_TPRB0_SPROF_COUNTERS_5_ALARMMODE PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   0.--1.       "[1 : 0]    COUNTERS_5_ALARMMODE                = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x005041A0$ PER_TESLA9X45_Part5.per -queue PCNOC_TPRB0_SPROF_COUNTERS_5_ALARMMODE"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x005041A4
tree " PCNOC_TPRB0_SPROF_COUNTERS_5_VAL [R]                              0x005041A4"
  group.long 0x0--0x3
   textline "POR 0xDEADBEEF [0xxxxxxxxx]    MASK =  "
   button "Add to Search History" "do &dp_cmm_path\PER_Print PCNOC_TPRB0_SPROF_COUNTERS_5_VAL PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.word 0 0.--15. 1  "[15 : 0]   COUNTERS_5_VAL                      = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x005041A4$ PER_TESLA9X45_Part5.per -queue PCNOC_TPRB0_SPROF_COUNTERS_5_VAL"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x005041B0
tree " PCNOC_TPRB0_SPROF_COUNTERS_6_SRC [RW]                             0x005041B0"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x0000003F    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print PCNOC_TPRB0_SPROF_COUNTERS_6_SRC PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   5.           "[ 5 ]      EXTEVENT                            = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   0.--4.       "[4 : 0]    INTEVENT                            = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?),0x08 (?),0x09 (?),0x0A (?),0x0B (?),0x0C (?),0x0D (?),0x0E (?),0x0F (?),0x10 (?),0x11 (?),0x12 (?),0x13 (?),0x14 (?),0x15 (?),0x16 (?),0x17 (?),0x18 (?),0x19 (?),0x1A (?),0x1B (?),0x1C (?),0x1D (?),0x1E (?),0x1F (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x005041B0$ PER_TESLA9X45_Part5.per -queue PCNOC_TPRB0_SPROF_COUNTERS_6_SRC"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x005041B4
tree " PCNOC_TPRB0_SPROF_COUNTERS_6_ALARMMODE [RW]                       0x005041B4"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x00000003    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print PCNOC_TPRB0_SPROF_COUNTERS_6_ALARMMODE PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   0.--1.       "[1 : 0]    COUNTERS_6_ALARMMODE                = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x005041B4$ PER_TESLA9X45_Part5.per -queue PCNOC_TPRB0_SPROF_COUNTERS_6_ALARMMODE"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x005041B8
tree " PCNOC_TPRB0_SPROF_COUNTERS_6_VAL [R]                              0x005041B8"
  group.long 0x0--0x3
   textline "POR 0xDEADBEEF [0xxxxxxxxx]    MASK =  "
   button "Add to Search History" "do &dp_cmm_path\PER_Print PCNOC_TPRB0_SPROF_COUNTERS_6_VAL PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.word 0 0.--15. 1  "[15 : 0]   COUNTERS_6_VAL                      = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x005041B8$ PER_TESLA9X45_Part5.per -queue PCNOC_TPRB0_SPROF_COUNTERS_6_VAL"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x005041C4
tree " PCNOC_TPRB0_SPROF_COUNTERS_7_SRC [RW]                             0x005041C4"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x0000003F    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print PCNOC_TPRB0_SPROF_COUNTERS_7_SRC PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   5.           "[ 5 ]      EXTEVENT                            = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   0.--4.       "[4 : 0]    INTEVENT                            = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?),0x08 (?),0x09 (?),0x0A (?),0x0B (?),0x0C (?),0x0D (?),0x0E (?),0x0F (?),0x10 (?),0x11 (?),0x12 (?),0x13 (?),0x14 (?),0x15 (?),0x16 (?),0x17 (?),0x18 (?),0x19 (?),0x1A (?),0x1B (?),0x1C (?),0x1D (?),0x1E (?),0x1F (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x005041C4$ PER_TESLA9X45_Part5.per -queue PCNOC_TPRB0_SPROF_COUNTERS_7_SRC"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x005041C8
tree " PCNOC_TPRB0_SPROF_COUNTERS_7_ALARMMODE [RW]                       0x005041C8"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x00000003    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print PCNOC_TPRB0_SPROF_COUNTERS_7_ALARMMODE PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   0.--1.       "[1 : 0]    COUNTERS_7_ALARMMODE                = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x005041C8$ PER_TESLA9X45_Part5.per -queue PCNOC_TPRB0_SPROF_COUNTERS_7_ALARMMODE"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x005041CC
tree " PCNOC_TPRB0_SPROF_COUNTERS_7_VAL [R]                              0x005041CC"
  group.long 0x0--0x3
   textline "POR 0xDEADBEEF [0xxxxxxxxx]    MASK =  "
   button "Add to Search History" "do &dp_cmm_path\PER_Print PCNOC_TPRB0_SPROF_COUNTERS_7_VAL PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.word 0 0.--15. 1  "[15 : 0]   COUNTERS_7_VAL                      = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x005041CC$ PER_TESLA9X45_Part5.per -queue PCNOC_TPRB0_SPROF_COUNTERS_7_VAL"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x005041D8
tree " PCNOC_TPRB0_SPROF_COUNTERS_8_SRC [RW]                             0x005041D8"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x0000003F    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print PCNOC_TPRB0_SPROF_COUNTERS_8_SRC PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   5.           "[ 5 ]      EXTEVENT                            = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   0.--4.       "[4 : 0]    INTEVENT                            = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?),0x08 (?),0x09 (?),0x0A (?),0x0B (?),0x0C (?),0x0D (?),0x0E (?),0x0F (?),0x10 (?),0x11 (?),0x12 (?),0x13 (?),0x14 (?),0x15 (?),0x16 (?),0x17 (?),0x18 (?),0x19 (?),0x1A (?),0x1B (?),0x1C (?),0x1D (?),0x1E (?),0x1F (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x005041D8$ PER_TESLA9X45_Part5.per -queue PCNOC_TPRB0_SPROF_COUNTERS_8_SRC"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x005041DC
tree " PCNOC_TPRB0_SPROF_COUNTERS_8_ALARMMODE [RW]                       0x005041DC"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x00000003    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print PCNOC_TPRB0_SPROF_COUNTERS_8_ALARMMODE PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   0.--1.       "[1 : 0]    COUNTERS_8_ALARMMODE                = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x005041DC$ PER_TESLA9X45_Part5.per -queue PCNOC_TPRB0_SPROF_COUNTERS_8_ALARMMODE"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x005041E0
tree " PCNOC_TPRB0_SPROF_COUNTERS_8_VAL [R]                              0x005041E0"
  group.long 0x0--0x3
   textline "POR 0xDEADBEEF [0xxxxxxxxx]    MASK =  "
   button "Add to Search History" "do &dp_cmm_path\PER_Print PCNOC_TPRB0_SPROF_COUNTERS_8_VAL PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.word 0 0.--15. 1  "[15 : 0]   COUNTERS_8_VAL                      = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x005041E0$ PER_TESLA9X45_Part5.per -queue PCNOC_TPRB0_SPROF_COUNTERS_8_VAL"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x005041EC
tree " PCNOC_TPRB0_SPROF_COUNTERS_9_SRC [RW]                             0x005041EC"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x0000003F    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print PCNOC_TPRB0_SPROF_COUNTERS_9_SRC PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   5.           "[ 5 ]      EXTEVENT                            = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   0.--4.       "[4 : 0]    INTEVENT                            = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?),0x08 (?),0x09 (?),0x0A (?),0x0B (?),0x0C (?),0x0D (?),0x0E (?),0x0F (?),0x10 (?),0x11 (?),0x12 (?),0x13 (?),0x14 (?),0x15 (?),0x16 (?),0x17 (?),0x18 (?),0x19 (?),0x1A (?),0x1B (?),0x1C (?),0x1D (?),0x1E (?),0x1F (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x005041EC$ PER_TESLA9X45_Part5.per -queue PCNOC_TPRB0_SPROF_COUNTERS_9_SRC"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x005041F0
tree " PCNOC_TPRB0_SPROF_COUNTERS_9_ALARMMODE [RW]                       0x005041F0"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x00000003    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print PCNOC_TPRB0_SPROF_COUNTERS_9_ALARMMODE PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   0.--1.       "[1 : 0]    COUNTERS_9_ALARMMODE                = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x005041F0$ PER_TESLA9X45_Part5.per -queue PCNOC_TPRB0_SPROF_COUNTERS_9_ALARMMODE"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x005041F4
tree " PCNOC_TPRB0_SPROF_COUNTERS_9_VAL [R]                              0x005041F4"
  group.long 0x0--0x3
   textline "POR 0xDEADBEEF [0xxxxxxxxx]    MASK =  "
   button "Add to Search History" "do &dp_cmm_path\PER_Print PCNOC_TPRB0_SPROF_COUNTERS_9_VAL PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.word 0 0.--15. 1  "[15 : 0]   COUNTERS_9_VAL                      = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x005041F4$ PER_TESLA9X45_Part5.per -queue PCNOC_TPRB0_SPROF_COUNTERS_9_VAL"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00504200
tree " PCNOC_TPRB0_SPROF_COUNTERS_10_SRC [RW]                            0x00504200"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x0000003F    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print PCNOC_TPRB0_SPROF_COUNTERS_10_SRC PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   5.           "[ 5 ]      EXTEVENT                            = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   0.--4.       "[4 : 0]    INTEVENT                            = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?),0x08 (?),0x09 (?),0x0A (?),0x0B (?),0x0C (?),0x0D (?),0x0E (?),0x0F (?),0x10 (?),0x11 (?),0x12 (?),0x13 (?),0x14 (?),0x15 (?),0x16 (?),0x17 (?),0x18 (?),0x19 (?),0x1A (?),0x1B (?),0x1C (?),0x1D (?),0x1E (?),0x1F (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00504200$ PER_TESLA9X45_Part5.per -queue PCNOC_TPRB0_SPROF_COUNTERS_10_SRC"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00504204
tree " PCNOC_TPRB0_SPROF_COUNTERS_10_ALARMMODE [RW]                      0x00504204"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x00000003    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print PCNOC_TPRB0_SPROF_COUNTERS_10_ALARMMODE PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   0.--1.       "[1 : 0]    COUNTERS_10_ALARMMODE               = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00504204$ PER_TESLA9X45_Part5.per -queue PCNOC_TPRB0_SPROF_COUNTERS_10_ALARMMODE"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00504208
tree " PCNOC_TPRB0_SPROF_COUNTERS_10_VAL [R]                             0x00504208"
  group.long 0x0--0x3
   textline "POR 0xDEADBEEF [0xxxxxxxxx]    MASK =  "
   button "Add to Search History" "do &dp_cmm_path\PER_Print PCNOC_TPRB0_SPROF_COUNTERS_10_VAL PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.word 0 0.--15. 1  "[15 : 0]   COUNTERS_10_VAL                     = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00504208$ PER_TESLA9X45_Part5.per -queue PCNOC_TPRB0_SPROF_COUNTERS_10_VAL"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00504214
tree " PCNOC_TPRB0_SPROF_COUNTERS_11_SRC [RW]                            0x00504214"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x0000003F    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print PCNOC_TPRB0_SPROF_COUNTERS_11_SRC PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   5.           "[ 5 ]      EXTEVENT                            = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   0.--4.       "[4 : 0]    INTEVENT                            = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?),0x08 (?),0x09 (?),0x0A (?),0x0B (?),0x0C (?),0x0D (?),0x0E (?),0x0F (?),0x10 (?),0x11 (?),0x12 (?),0x13 (?),0x14 (?),0x15 (?),0x16 (?),0x17 (?),0x18 (?),0x19 (?),0x1A (?),0x1B (?),0x1C (?),0x1D (?),0x1E (?),0x1F (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00504214$ PER_TESLA9X45_Part5.per -queue PCNOC_TPRB0_SPROF_COUNTERS_11_SRC"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00504218
tree " PCNOC_TPRB0_SPROF_COUNTERS_11_ALARMMODE [RW]                      0x00504218"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x00000003    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print PCNOC_TPRB0_SPROF_COUNTERS_11_ALARMMODE PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   0.--1.       "[1 : 0]    COUNTERS_11_ALARMMODE               = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00504218$ PER_TESLA9X45_Part5.per -queue PCNOC_TPRB0_SPROF_COUNTERS_11_ALARMMODE"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0050421C
tree " PCNOC_TPRB0_SPROF_COUNTERS_11_VAL [R]                             0x0050421C"
  group.long 0x0--0x3
   textline "POR 0xDEADBEEF [0xxxxxxxxx]    MASK =  "
   button "Add to Search History" "do &dp_cmm_path\PER_Print PCNOC_TPRB0_SPROF_COUNTERS_11_VAL PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.word 0 0.--15. 1  "[15 : 0]   COUNTERS_11_VAL                     = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0050421C$ PER_TESLA9X45_Part5.per -queue PCNOC_TPRB0_SPROF_COUNTERS_11_VAL"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00504228
tree " PCNOC_TPRB0_SPROF_COUNTERS_12_SRC [RW]                            0x00504228"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x0000003F    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print PCNOC_TPRB0_SPROF_COUNTERS_12_SRC PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   5.           "[ 5 ]      EXTEVENT                            = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   0.--4.       "[4 : 0]    INTEVENT                            = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?),0x08 (?),0x09 (?),0x0A (?),0x0B (?),0x0C (?),0x0D (?),0x0E (?),0x0F (?),0x10 (?),0x11 (?),0x12 (?),0x13 (?),0x14 (?),0x15 (?),0x16 (?),0x17 (?),0x18 (?),0x19 (?),0x1A (?),0x1B (?),0x1C (?),0x1D (?),0x1E (?),0x1F (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00504228$ PER_TESLA9X45_Part5.per -queue PCNOC_TPRB0_SPROF_COUNTERS_12_SRC"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0050422C
tree " PCNOC_TPRB0_SPROF_COUNTERS_12_ALARMMODE [RW]                      0x0050422C"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x00000003    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print PCNOC_TPRB0_SPROF_COUNTERS_12_ALARMMODE PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   0.--1.       "[1 : 0]    COUNTERS_12_ALARMMODE               = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0050422C$ PER_TESLA9X45_Part5.per -queue PCNOC_TPRB0_SPROF_COUNTERS_12_ALARMMODE"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00504230
tree " PCNOC_TPRB0_SPROF_COUNTERS_12_VAL [R]                             0x00504230"
  group.long 0x0--0x3
   textline "POR 0xDEADBEEF [0xxxxxxxxx]    MASK =  "
   button "Add to Search History" "do &dp_cmm_path\PER_Print PCNOC_TPRB0_SPROF_COUNTERS_12_VAL PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.word 0 0.--15. 1  "[15 : 0]   COUNTERS_12_VAL                     = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00504230$ PER_TESLA9X45_Part5.per -queue PCNOC_TPRB0_SPROF_COUNTERS_12_VAL"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0050423C
tree " PCNOC_TPRB0_SPROF_COUNTERS_13_SRC [RW]                            0x0050423C"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x0000003F    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print PCNOC_TPRB0_SPROF_COUNTERS_13_SRC PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   5.           "[ 5 ]      EXTEVENT                            = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   0.--4.       "[4 : 0]    INTEVENT                            = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?),0x08 (?),0x09 (?),0x0A (?),0x0B (?),0x0C (?),0x0D (?),0x0E (?),0x0F (?),0x10 (?),0x11 (?),0x12 (?),0x13 (?),0x14 (?),0x15 (?),0x16 (?),0x17 (?),0x18 (?),0x19 (?),0x1A (?),0x1B (?),0x1C (?),0x1D (?),0x1E (?),0x1F (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0050423C$ PER_TESLA9X45_Part5.per -queue PCNOC_TPRB0_SPROF_COUNTERS_13_SRC"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00504240
tree " PCNOC_TPRB0_SPROF_COUNTERS_13_ALARMMODE [RW]                      0x00504240"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x00000003    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print PCNOC_TPRB0_SPROF_COUNTERS_13_ALARMMODE PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   0.--1.       "[1 : 0]    COUNTERS_13_ALARMMODE               = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00504240$ PER_TESLA9X45_Part5.per -queue PCNOC_TPRB0_SPROF_COUNTERS_13_ALARMMODE"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00504244
tree " PCNOC_TPRB0_SPROF_COUNTERS_13_VAL [R]                             0x00504244"
  group.long 0x0--0x3
   textline "POR 0xDEADBEEF [0xxxxxxxxx]    MASK =  "
   button "Add to Search History" "do &dp_cmm_path\PER_Print PCNOC_TPRB0_SPROF_COUNTERS_13_VAL PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.word 0 0.--15. 1  "[15 : 0]   COUNTERS_13_VAL                     = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00504244$ PER_TESLA9X45_Part5.per -queue PCNOC_TPRB0_SPROF_COUNTERS_13_VAL"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00504250
tree " PCNOC_TPRB0_SPROF_COUNTERS_14_SRC [RW]                            0x00504250"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x0000003F    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print PCNOC_TPRB0_SPROF_COUNTERS_14_SRC PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   5.           "[ 5 ]      EXTEVENT                            = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   0.--4.       "[4 : 0]    INTEVENT                            = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?),0x08 (?),0x09 (?),0x0A (?),0x0B (?),0x0C (?),0x0D (?),0x0E (?),0x0F (?),0x10 (?),0x11 (?),0x12 (?),0x13 (?),0x14 (?),0x15 (?),0x16 (?),0x17 (?),0x18 (?),0x19 (?),0x1A (?),0x1B (?),0x1C (?),0x1D (?),0x1E (?),0x1F (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00504250$ PER_TESLA9X45_Part5.per -queue PCNOC_TPRB0_SPROF_COUNTERS_14_SRC"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00504254
tree " PCNOC_TPRB0_SPROF_COUNTERS_14_ALARMMODE [RW]                      0x00504254"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x00000003    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print PCNOC_TPRB0_SPROF_COUNTERS_14_ALARMMODE PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   0.--1.       "[1 : 0]    COUNTERS_14_ALARMMODE               = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00504254$ PER_TESLA9X45_Part5.per -queue PCNOC_TPRB0_SPROF_COUNTERS_14_ALARMMODE"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00504258
tree " PCNOC_TPRB0_SPROF_COUNTERS_14_VAL [R]                             0x00504258"
  group.long 0x0--0x3
   textline "POR 0xDEADBEEF [0xxxxxxxxx]    MASK =  "
   button "Add to Search History" "do &dp_cmm_path\PER_Print PCNOC_TPRB0_SPROF_COUNTERS_14_VAL PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.word 0 0.--15. 1  "[15 : 0]   COUNTERS_14_VAL                     = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00504258$ PER_TESLA9X45_Part5.per -queue PCNOC_TPRB0_SPROF_COUNTERS_14_VAL"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00504264
tree " PCNOC_TPRB0_SPROF_COUNTERS_15_SRC [RW]                            0x00504264"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x0000003F    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print PCNOC_TPRB0_SPROF_COUNTERS_15_SRC PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   5.           "[ 5 ]      EXTEVENT                            = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   0.--4.       "[4 : 0]    INTEVENT                            = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?),0x08 (?),0x09 (?),0x0A (?),0x0B (?),0x0C (?),0x0D (?),0x0E (?),0x0F (?),0x10 (?),0x11 (?),0x12 (?),0x13 (?),0x14 (?),0x15 (?),0x16 (?),0x17 (?),0x18 (?),0x19 (?),0x1A (?),0x1B (?),0x1C (?),0x1D (?),0x1E (?),0x1F (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00504264$ PER_TESLA9X45_Part5.per -queue PCNOC_TPRB0_SPROF_COUNTERS_15_SRC"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00504268
tree " PCNOC_TPRB0_SPROF_COUNTERS_15_ALARMMODE [RW]                      0x00504268"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x00000003    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print PCNOC_TPRB0_SPROF_COUNTERS_15_ALARMMODE PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   0.--1.       "[1 : 0]    COUNTERS_15_ALARMMODE               = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00504268$ PER_TESLA9X45_Part5.per -queue PCNOC_TPRB0_SPROF_COUNTERS_15_ALARMMODE"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0050426C
tree " PCNOC_TPRB0_SPROF_COUNTERS_15_VAL [R]                             0x0050426C"
  group.long 0x0--0x3
   textline "POR 0xDEADBEEF [0xxxxxxxxx]    MASK =  "
   button "Add to Search History" "do &dp_cmm_path\PER_Print PCNOC_TPRB0_SPROF_COUNTERS_15_VAL PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.word 0 0.--15. 1  "[15 : 0]   COUNTERS_15_VAL                     = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0050426C$ PER_TESLA9X45_Part5.per -queue PCNOC_TPRB0_SPROF_COUNTERS_15_VAL"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00507000
tree " PCNOC_CRYPTO0_QOS_ID_COREID [R]                                   0x00507000"
  group.long 0x0--0x3
   textline "POR 0xAB94C204    MASK = 0xFFFFFFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print PCNOC_CRYPTO0_QOS_ID_COREID PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.long 0 8.--31. 1  "[31 : 8]   CORECHECKSUM                        = "
   textline ""
   hexmask.long.byte 0 0.--7. 1   "[7 : 0]    CORETYPEID                          = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00507000$ PER_TESLA9X45_Part5.per -queue PCNOC_CRYPTO0_QOS_ID_COREID"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00507004
tree " PCNOC_CRYPTO0_QOS_ID_REVISIONID [R]                               0x00507004"
  group.long 0x0--0x3
   textline "POR 0x00049C00    MASK = 0xFFFFFFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print PCNOC_CRYPTO0_QOS_ID_REVISIONID PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.long 0 8.--31. 1  "[31 : 8]   FLEXNOCID                           = "
   textline ""
   hexmask.long.byte 0 0.--7. 1   "[7 : 0]    USERID                              = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00507004$ PER_TESLA9X45_Part5.per -queue PCNOC_CRYPTO0_QOS_ID_REVISIONID"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00507008
tree " PCNOC_CRYPTO0_QOS_PRIORITY [RW]                                   0x00507008"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x0000000F    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print PCNOC_CRYPTO0_QOS_PRIORITY PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   2.--3.       "[3 : 2]    P1                                  = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?)"
   textline ""
   bitfld.long 0x0   0.--1.       "[1 : 0]    P0                                  = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00507008$ PER_TESLA9X45_Part5.per -queue PCNOC_CRYPTO0_QOS_PRIORITY"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0050700C
tree " PCNOC_CRYPTO0_QOS_MODE [RW]                                       0x0050700C"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x00000003    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print PCNOC_CRYPTO0_QOS_MODE PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   0.--1.       "[1 : 0]    MODE                                = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0050700C$ PER_TESLA9X45_Part5.per -queue PCNOC_CRYPTO0_QOS_MODE"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00507018
tree " PCNOC_CRYPTO0_QOS_EXTCONTROL [RW]                                 0x00507018"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x00000007    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print PCNOC_CRYPTO0_QOS_EXTCONTROL PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   2.           "[ 2 ]      INTCLKEN                            = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   1.           "[ 1 ]      EXTTHREN                            = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   0.           "[ 0 ]      SOCKETQOSEN                         = " "0x00 (?),0x01 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00507018$ PER_TESLA9X45_Part5.per -queue PCNOC_CRYPTO0_QOS_EXTCONTROL"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0050C000
tree " PCNOC_QHM1_QOS_ID_COREID [R]                                      0x0050C000"
  group.long 0x0--0x3
   textline "POR 0xB88D1704    MASK = 0xFFFFFFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print PCNOC_QHM1_QOS_ID_COREID PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.long 0 8.--31. 1  "[31 : 8]   CORECHECKSUM                        = "
   textline ""
   hexmask.long.byte 0 0.--7. 1   "[7 : 0]    CORETYPEID                          = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0050C000$ PER_TESLA9X45_Part5.per -queue PCNOC_QHM1_QOS_ID_COREID"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0050C004
tree " PCNOC_QHM1_QOS_ID_REVISIONID [R]                                  0x0050C004"
  group.long 0x0--0x3
   textline "POR 0x00049C00    MASK = 0xFFFFFFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print PCNOC_QHM1_QOS_ID_REVISIONID PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.long 0 8.--31. 1  "[31 : 8]   FLEXNOCID                           = "
   textline ""
   hexmask.long.byte 0 0.--7. 1   "[7 : 0]    USERID                              = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0050C004$ PER_TESLA9X45_Part5.per -queue PCNOC_QHM1_QOS_ID_REVISIONID"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0050C008
tree " PCNOC_QHM1_QOS_PRIORITY [RW]                                      0x0050C008"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x0000000F    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print PCNOC_QHM1_QOS_PRIORITY PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   2.--3.       "[3 : 2]    P1                                  = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?)"
   textline ""
   bitfld.long 0x0   0.--1.       "[1 : 0]    P0                                  = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0050C008$ PER_TESLA9X45_Part5.per -queue PCNOC_QHM1_QOS_PRIORITY"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0050C00C
tree " PCNOC_QHM1_QOS_MODE [RW]                                          0x0050C00C"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x00000003    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print PCNOC_QHM1_QOS_MODE PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   0.--1.       "[1 : 0]    MODE                                = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0050C00C$ PER_TESLA9X45_Part5.per -queue PCNOC_QHM1_QOS_MODE"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0050C018
tree " PCNOC_QHM1_QOS_EXTCONTROL [RW]                                    0x0050C018"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x00000007    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print PCNOC_QHM1_QOS_EXTCONTROL PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   2.           "[ 2 ]      INTCLKEN                            = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   1.           "[ 1 ]      EXTTHREN                            = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   0.           "[ 0 ]      SOCKETQOSEN                         = " "0x00 (?),0x01 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0050C018$ PER_TESLA9X45_Part5.per -queue PCNOC_QHM1_QOS_EXTCONTROL"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0050D000
tree " PCNOC_QHM2_QOS_ID_COREID [R]                                      0x0050D000"
  group.long 0x0--0x3
   textline "POR 0x5F073304    MASK = 0xFFFFFFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print PCNOC_QHM2_QOS_ID_COREID PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.long 0 8.--31. 1  "[31 : 8]   CORECHECKSUM                        = "
   textline ""
   hexmask.long.byte 0 0.--7. 1   "[7 : 0]    CORETYPEID                          = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0050D000$ PER_TESLA9X45_Part5.per -queue PCNOC_QHM2_QOS_ID_COREID"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0050D004
tree " PCNOC_QHM2_QOS_ID_REVISIONID [R]                                  0x0050D004"
  group.long 0x0--0x3
   textline "POR 0x00049C00    MASK = 0xFFFFFFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print PCNOC_QHM2_QOS_ID_REVISIONID PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.long 0 8.--31. 1  "[31 : 8]   FLEXNOCID                           = "
   textline ""
   hexmask.long.byte 0 0.--7. 1   "[7 : 0]    USERID                              = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0050D004$ PER_TESLA9X45_Part5.per -queue PCNOC_QHM2_QOS_ID_REVISIONID"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0050D008
tree " PCNOC_QHM2_QOS_PRIORITY [RW]                                      0x0050D008"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x0000000F    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print PCNOC_QHM2_QOS_PRIORITY PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   2.--3.       "[3 : 2]    P1                                  = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?)"
   textline ""
   bitfld.long 0x0   0.--1.       "[1 : 0]    P0                                  = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0050D008$ PER_TESLA9X45_Part5.per -queue PCNOC_QHM2_QOS_PRIORITY"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0050D00C
tree " PCNOC_QHM2_QOS_MODE [RW]                                          0x0050D00C"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x00000003    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print PCNOC_QHM2_QOS_MODE PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   0.--1.       "[1 : 0]    MODE                                = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0050D00C$ PER_TESLA9X45_Part5.per -queue PCNOC_QHM2_QOS_MODE"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0050D018
tree " PCNOC_QHM2_QOS_EXTCONTROL [RW]                                    0x0050D018"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x00000007    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print PCNOC_QHM2_QOS_EXTCONTROL PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   2.           "[ 2 ]      INTCLKEN                            = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   1.           "[ 1 ]      EXTTHREN                            = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   0.           "[ 0 ]      SOCKETQOSEN                         = " "0x00 (?),0x01 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0050D018$ PER_TESLA9X45_Part5.per -queue PCNOC_QHM2_QOS_EXTCONTROL"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00510000
tree " PCNOC_SNOC_QOS_ID_COREID [R]                                      0x00510000"
  group.long 0x0--0x3
   textline "POR 0xE0779004    MASK = 0xFFFFFFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print PCNOC_SNOC_QOS_ID_COREID PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.long 0 8.--31. 1  "[31 : 8]   CORECHECKSUM                        = "
   textline ""
   hexmask.long.byte 0 0.--7. 1   "[7 : 0]    CORETYPEID                          = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00510000$ PER_TESLA9X45_Part5.per -queue PCNOC_SNOC_QOS_ID_COREID"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00510004
tree " PCNOC_SNOC_QOS_ID_REVISIONID [R]                                  0x00510004"
  group.long 0x0--0x3
   textline "POR 0x00049C00    MASK = 0xFFFFFFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print PCNOC_SNOC_QOS_ID_REVISIONID PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.long 0 8.--31. 1  "[31 : 8]   FLEXNOCID                           = "
   textline ""
   hexmask.long.byte 0 0.--7. 1   "[7 : 0]    USERID                              = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00510004$ PER_TESLA9X45_Part5.per -queue PCNOC_SNOC_QOS_ID_REVISIONID"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00510008
tree " PCNOC_SNOC_QOS_PRIORITY [RW]                                      0x00510008"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x0000000F    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print PCNOC_SNOC_QOS_PRIORITY PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   2.--3.       "[3 : 2]    P1                                  = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?)"
   textline ""
   bitfld.long 0x0   0.--1.       "[1 : 0]    P0                                  = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00510008$ PER_TESLA9X45_Part5.per -queue PCNOC_SNOC_QOS_PRIORITY"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0051000C
tree " PCNOC_SNOC_QOS_MODE [RW]                                          0x0051000C"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x00000003    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print PCNOC_SNOC_QOS_MODE PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   0.--1.       "[1 : 0]    MODE                                = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0051000C$ PER_TESLA9X45_Part5.per -queue PCNOC_SNOC_QOS_MODE"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00510018
tree " PCNOC_SNOC_QOS_EXTCONTROL [RW]                                    0x00510018"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x00000007    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print PCNOC_SNOC_QOS_EXTCONTROL PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   2.           "[ 2 ]      INTCLKEN                            = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   1.           "[ 1 ]      EXTTHREN                            = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   0.           "[ 0 ]      SOCKETQOSEN                         = " "0x00 (?),0x01 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00510018$ PER_TESLA9X45_Part5.per -queue PCNOC_SNOC_QOS_EXTCONTROL"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00048000
tree " RBCPR_VERSION [R]                                                 0x00048000"
  group.long 0x0--0x3
   textline "POR 0x10020000    MASK = 0xFFFFFFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print RBCPR_VERSION PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.long 0 0.--31. 1  "[31 : 0]   RBCPR_VERSION                       = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00048000$ PER_TESLA9X45_Part5.per -queue RBCPR_VERSION"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00048020
tree " RBCPR_SENSOR_MASK0 [RW]                                           0x00048020"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0xFFFFFFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print RBCPR_SENSOR_MASK0 PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.long 0 0.--31. 1  "[31 : 0]   SENSOR_MASK                         = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00048020$ PER_TESLA9X45_Part5.per -queue RBCPR_SENSOR_MASK0"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00048024
tree " RBCPR_SENSOR_MASK1 [RW]                                           0x00048024"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0xFFFFFFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print RBCPR_SENSOR_MASK1 PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.long 0 0.--31. 1  "[31 : 0]   SENSOR_MASK                         = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00048024$ PER_TESLA9X45_Part5.per -queue RBCPR_SENSOR_MASK1"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00048028
tree " RBCPR_SENSOR_MASK2 [RW]                                           0x00048028"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0xFFFFFFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print RBCPR_SENSOR_MASK2 PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.long 0 0.--31. 1  "[31 : 0]   SENSOR_MASK                         = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00048028$ PER_TESLA9X45_Part5.per -queue RBCPR_SENSOR_MASK2"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0004802C
tree " RBCPR_SENSOR_MASK3 [RW]                                           0x0004802C"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0xFFFFFFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print RBCPR_SENSOR_MASK3 PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.long 0 0.--31. 1  "[31 : 0]   SENSOR_MASK                         = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0004802C$ PER_TESLA9X45_Part5.per -queue RBCPR_SENSOR_MASK3"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00048030
tree " RBCPR_SENSOR_BYPASS0 [RW]                                         0x00048030"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0xFFFFFFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print RBCPR_SENSOR_BYPASS0 PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.long 0 0.--31. 1  "[31 : 0]   SENSOR_BYPASS                       = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00048030$ PER_TESLA9X45_Part5.per -queue RBCPR_SENSOR_BYPASS0"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00048034
tree " RBCPR_SENSOR_BYPASS1 [RW]                                         0x00048034"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0xFFFFFFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print RBCPR_SENSOR_BYPASS1 PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.long 0 0.--31. 1  "[31 : 0]   SENSOR_BYPASS                       = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00048034$ PER_TESLA9X45_Part5.per -queue RBCPR_SENSOR_BYPASS1"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00048038
tree " RBCPR_SENSOR_BYPASS2 [RW]                                         0x00048038"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0xFFFFFFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print RBCPR_SENSOR_BYPASS2 PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.long 0 0.--31. 1  "[31 : 0]   SENSOR_BYPASS                       = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00048038$ PER_TESLA9X45_Part5.per -queue RBCPR_SENSOR_BYPASS2"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0004803C
tree " RBCPR_SENSOR_BYPASS3 [RW]                                         0x0004803C"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0xFFFFFFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print RBCPR_SENSOR_BYPASS3 PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.long 0 0.--31. 1  "[31 : 0]   SENSOR_BYPASS                       = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0004803C$ PER_TESLA9X45_Part5.per -queue RBCPR_SENSOR_BYPASS3"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00048040
tree " RBIF_PMIC_ADDR [RW]                                               0x00048040"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x00C03C03    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print RBIF_PMIC_ADDR PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   22.--23.     "[23 : 22]  RBIF_PMIC_MX_DATA_MSB               = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?)"
   textline ""
   bitfld.long 0x0   12.--13.     "[13 : 12]  RBIF_PMIC_MX_ADDR                   = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?)"
   textline ""
   bitfld.long 0x0   10.--11.     "[11 : 10]  RBIF_PMIC_CX_DATA_MSB               = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?)"
   textline ""
   bitfld.long 0x0   0.--1.       "[1 : 0]    RBIF_PMIC_CX_ADDR                   = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00048040$ PER_TESLA9X45_Part5.per -queue RBIF_PMIC_ADDR"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00048044
tree " RBCPR_TIMER_INTERVAL [RW]                                         0x00048044"
  group.long 0x0--0x3
   textline "POR 0x0000FFFF    MASK = 0xFFFFFFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print RBCPR_TIMER_INTERVAL PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.long 0 0.--31. 1  "[31 : 0]   INTERVAL                            = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00048044$ PER_TESLA9X45_Part5.per -queue RBCPR_TIMER_INTERVAL"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00048048
tree " RBIF_LIMIT [RW]                                                   0x00048048"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x00000FFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print RBIF_LIMIT PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   6.--11.      "[11 : 6]   CEILING                             = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?),0x08 (?),0x09 (?),0x0A (?),0x0B (?),0x0C (?),0x0D (?),0x0E (?),0x0F (?),0x10 (?),0x11 (?),0x12 (?),0x13 (?),0x14 (?),0x15 (?),0x16 (?),0x17 (?),0x18 (?),0x19 (?),0x1A (?),0x1B (?),0x1C (?),0x1D (?),0x1E (?),0x1F (?),0x20 (?),0x21 (?),0x22 (?),0x23 (?),0x24 (?),0x25 (?),0x26 (?),0x27 (?),0x28 (?),0x29 (?),0x2A (?),0x2B (?),0x2C (?),0x2D (?),0x2E (?),0x2F (?),0x30 (?),0x31 (?),0x32 (?),0x33 (?),0x34 (?),0x35 (?),0x36 (?),0x37 (?),0x38 (?),0x39 (?),0x3A (?),0x3B (?),0x3C (?),0x3D (?),0x3E (?),0x3F (?)"
   textline ""
   bitfld.long 0x0   0.--5.       "[5 : 0]    FLOOR                               = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?),0x08 (?),0x09 (?),0x0A (?),0x0B (?),0x0C (?),0x0D (?),0x0E (?),0x0F (?),0x10 (?),0x11 (?),0x12 (?),0x13 (?),0x14 (?),0x15 (?),0x16 (?),0x17 (?),0x18 (?),0x19 (?),0x1A (?),0x1B (?),0x1C (?),0x1D (?),0x1E (?),0x1F (?),0x20 (?),0x21 (?),0x22 (?),0x23 (?),0x24 (?),0x25 (?),0x26 (?),0x27 (?),0x28 (?),0x29 (?),0x2A (?),0x2B (?),0x2C (?),0x2D (?),0x2E (?),0x2F (?),0x30 (?),0x31 (?),0x32 (?),0x33 (?),0x34 (?),0x35 (?),0x36 (?),0x37 (?),0x38 (?),0x39 (?),0x3A (?),0x3B (?),0x3C (?),0x3D (?),0x3E (?),0x3F (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00048048$ PER_TESLA9X45_Part5.per -queue RBIF_LIMIT"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0004804C
tree " RBIF_TIMER_ADJUST [RW]                                            0x0004804C"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x0001FFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print RBIF_TIMER_ADJUST PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   16.          "[ 16 ]     AUTO_LOOP_DISABLE                   = " "0x00 (?),0x01 (?)"
   textline ""
   hexmask.long.byte 0 8.--15. 1  "[15 : 8]   CLAMP_TIMER_INTERVAL                = "
   textline ""
   bitfld.long 0x0   4.--7.       "[7 : 4]    CONSECUTIVE_DN                      = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?),0x08 (?),0x09 (?),0x0A (?),0x0B (?),0x0C (?),0x0D (?),0x0E (?),0x0F (?)"
   textline ""
   bitfld.long 0x0   0.--3.       "[3 : 0]    CONSECUTIVE_UP                      = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?),0x08 (?),0x09 (?),0x0A (?),0x0B (?),0x0C (?),0x0D (?),0x0E (?),0x0F (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0004804C$ PER_TESLA9X45_Part5.per -queue RBIF_TIMER_ADJUST"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00048060
tree " RBCPR_GCNT_TARGET0 [RW]                                           0x00048060"
  group.long 0x0--0x3
   textline "POR 0x000203E8    MASK = 0x003FFFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print RBCPR_GCNT_TARGET0 PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.word 0 12.--21. 1 "[21 : 12]  GCNT0                               = "
   textline ""
   hexmask.long.word 0 0.--11. 1  "[11 : 0]   TARGET0                             = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00048060$ PER_TESLA9X45_Part5.per -queue RBCPR_GCNT_TARGET0"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00048064
tree " RBCPR_GCNT_TARGET1 [RW]                                           0x00048064"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x003FFFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print RBCPR_GCNT_TARGET1 PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.word 0 12.--21. 1 "[21 : 12]  GCNT1                               = "
   textline ""
   hexmask.long.word 0 0.--11. 1  "[11 : 0]   TARGET1                             = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00048064$ PER_TESLA9X45_Part5.per -queue RBCPR_GCNT_TARGET1"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00048068
tree " RBCPR_GCNT_TARGET2 [RW]                                           0x00048068"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x003FFFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print RBCPR_GCNT_TARGET2 PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.word 0 12.--21. 1 "[21 : 12]  GCNT2                               = "
   textline ""
   hexmask.long.word 0 0.--11. 1  "[11 : 0]   TARGET2                             = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00048068$ PER_TESLA9X45_Part5.per -queue RBCPR_GCNT_TARGET2"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0004806C
tree " RBCPR_GCNT_TARGET3 [RW]                                           0x0004806C"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x003FFFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print RBCPR_GCNT_TARGET3 PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.word 0 12.--21. 1 "[21 : 12]  GCNT3                               = "
   textline ""
   hexmask.long.word 0 0.--11. 1  "[11 : 0]   TARGET3                             = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0004806C$ PER_TESLA9X45_Part5.per -queue RBCPR_GCNT_TARGET3"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00048070
tree " RBCPR_GCNT_TARGET4 [RW]                                           0x00048070"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x003FFFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print RBCPR_GCNT_TARGET4 PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.word 0 12.--21. 1 "[21 : 12]  GCNT4                               = "
   textline ""
   hexmask.long.word 0 0.--11. 1  "[11 : 0]   TARGET4                             = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00048070$ PER_TESLA9X45_Part5.per -queue RBCPR_GCNT_TARGET4"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00048074
tree " RBCPR_GCNT_TARGET5 [RW]                                           0x00048074"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x003FFFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print RBCPR_GCNT_TARGET5 PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.word 0 12.--21. 1 "[21 : 12]  GCNT5                               = "
   textline ""
   hexmask.long.word 0 0.--11. 1  "[11 : 0]   TARGET5                             = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00048074$ PER_TESLA9X45_Part5.per -queue RBCPR_GCNT_TARGET5"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00048078
tree " RBCPR_GCNT_TARGET6 [RW]                                           0x00048078"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x003FFFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print RBCPR_GCNT_TARGET6 PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.word 0 12.--21. 1 "[21 : 12]  GCNT6                               = "
   textline ""
   hexmask.long.word 0 0.--11. 1  "[11 : 0]   TARGET6                             = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00048078$ PER_TESLA9X45_Part5.per -queue RBCPR_GCNT_TARGET6"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0004807C
tree " RBCPR_GCNT_TARGET7 [RW]                                           0x0004807C"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x003FFFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print RBCPR_GCNT_TARGET7 PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.word 0 12.--21. 1 "[21 : 12]  GCNT7                               = "
   textline ""
   hexmask.long.word 0 0.--11. 1  "[11 : 0]   TARGET7                             = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0004807C$ PER_TESLA9X45_Part5.per -queue RBCPR_GCNT_TARGET7"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00048080
tree " RBCPR_STEP_QUOT [RW]                                              0x00048080"
  group.long 0x0--0x3
   textline "POR 0x00000032    MASK = 0x00001FFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print RBCPR_STEP_QUOT PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   8.--12.      "[12 : 8]   IDLE_CLOCKS                         = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?),0x08 (?),0x09 (?),0x0A (?),0x0B (?),0x0C (?),0x0D (?),0x0E (?),0x0F (?),0x10 (?),0x11 (?),0x12 (?),0x13 (?),0x14 (?),0x15 (?),0x16 (?),0x17 (?),0x18 (?),0x19 (?),0x1A (?),0x1B (?),0x1C (?),0x1D (?),0x1E (?),0x1F (?)"
   textline ""
   hexmask.long.byte 0 0.--7. 1   "[7 : 0]    STEP_QUOT                           = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00048080$ PER_TESLA9X45_Part5.per -queue RBCPR_STEP_QUOT"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00048090
tree " RBCPR_CTL [RW]                                                    0x00048090"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0xFF7FFFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print RBCPR_CTL PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   28.--31.     "[31 : 28]  DN_THRESHOLD                        = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?),0x08 (?),0x09 (?),0x0A (?),0x0B (?),0x0C (?),0x0D (?),0x0E (?),0x0F (?)"
   textline ""
   bitfld.long 0x0   24.--27.     "[27 : 24]  UP_THRESHOLD                        = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?),0x08 (?),0x09 (?),0x0A (?),0x0B (?),0x0C (?),0x0D (?),0x0E (?),0x0F (?)"
   textline ""
   bitfld.long 0x0   18.--22.     "[22 : 18]  MIN_MX_CX_DELTA                     = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?),0x08 (?),0x09 (?),0x0A (?),0x0B (?),0x0C (?),0x0D (?),0x0E (?),0x0F (?),0x10 (?),0x11 (?),0x12 (?),0x13 (?),0x14 (?),0x15 (?),0x16 (?),0x17 (?),0x18 (?),0x19 (?),0x1A (?),0x1B (?),0x1C (?),0x1D (?),0x1E (?),0x1F (?)"
   textline ""
   bitfld.long 0x0   17.          "[ 17 ]     CPR_DISABLE_VALID                   = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   12.--16.     "[16 : 12]  MAX_MX_CX_DELTA                     = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?),0x08 (?),0x09 (?),0x0A (?),0x0B (?),0x0C (?),0x0D (?),0x0E (?),0x0F (?),0x10 (?),0x11 (?),0x12 (?),0x13 (?),0x14 (?),0x15 (?),0x16 (?),0x17 (?),0x18 (?),0x19 (?),0x1A (?),0x1B (?),0x1C (?),0x1D (?),0x1E (?),0x1F (?)"
   textline ""
   bitfld.long 0x0   11.          "[ 11 ]     HW_TO_PMIC_MX_EN                    = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   10.          "[ 10 ]     COUNT_MODE                          = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   7.--9.       "[9 : 7]    DEBUG_BUS_SEL                       = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?)"
   textline ""
   bitfld.long 0x0   6.           "[ 6 ]      SW_AUTO_CONT_NACK_DN_EN             = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   5.           "[ 5 ]      SW_AUTO_CONT_ACK_EN                 = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   4.           "[ 4 ]      HW_TO_PMIC_EN                       = " "0x00 (SW_MODE),0x01 (HW_MODE)"
   textline ""
   bitfld.long 0x0   3.           "[ 3 ]      TIMER_EN                            = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   2.           "[ 2 ]      INCR_MODE                           = " "0x00 (PROPORTIONAL_TO_QUOT),0x01 (INCREMENTAL)"
   textline ""
   bitfld.long 0x0   1.           "[ 1 ]      FORCE_TIMER                         = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   0.           "[ 0 ]      LOOP_EN                             = " "0x00 (?),0x01 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00048090$ PER_TESLA9X45_Part5.per -queue RBCPR_CTL"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00048094
tree " RBIF_SW_VLEVEL [RW]                                               0x00048094"
  group.long 0x0--0x3
   textline "POR 0x00000820    MASK = 0x00000FFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print RBIF_SW_VLEVEL PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   6.--11.      "[11 : 6]   SW_MX_VLEVEL                        = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?),0x08 (?),0x09 (?),0x0A (?),0x0B (?),0x0C (?),0x0D (?),0x0E (?),0x0F (?),0x10 (?),0x11 (?),0x12 (?),0x13 (?),0x14 (?),0x15 (?),0x16 (?),0x17 (?),0x18 (?),0x19 (?),0x1A (?),0x1B (?),0x1C (?),0x1D (?),0x1E (?),0x1F (?),0x20 (?),0x21 (?),0x22 (?),0x23 (?),0x24 (?),0x25 (?),0x26 (?),0x27 (?),0x28 (?),0x29 (?),0x2A (?),0x2B (?),0x2C (?),0x2D (?),0x2E (?),0x2F (?),0x30 (?),0x31 (?),0x32 (?),0x33 (?),0x34 (?),0x35 (?),0x36 (?),0x37 (?),0x38 (?),0x39 (?),0x3A (?),0x3B (?),0x3C (?),0x3D (?),0x3E (?),0x3F (?)"
   textline ""
   bitfld.long 0x0   0.--5.       "[5 : 0]    SW_VLEVEL                           = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?),0x08 (?),0x09 (?),0x0A (?),0x0B (?),0x0C (?),0x0D (?),0x0E (?),0x0F (?),0x10 (?),0x11 (?),0x12 (?),0x13 (?),0x14 (?),0x15 (?),0x16 (?),0x17 (?),0x18 (?),0x19 (?),0x1A (?),0x1B (?),0x1C (?),0x1D (?),0x1E (?),0x1F (?),0x20 (?),0x21 (?),0x22 (?),0x23 (?),0x24 (?),0x25 (?),0x26 (?),0x27 (?),0x28 (?),0x29 (?),0x2A (?),0x2B (?),0x2C (?),0x2D (?),0x2E (?),0x2F (?),0x30 (?),0x31 (?),0x32 (?),0x33 (?),0x34 (?),0x35 (?),0x36 (?),0x37 (?),0x38 (?),0x39 (?),0x3A (?),0x3B (?),0x3C (?),0x3D (?),0x3E (?),0x3F (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00048094$ PER_TESLA9X45_Part5.per -queue RBIF_SW_VLEVEL"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00048098
tree " RBIF_CONT_ACK_CMD [C]                                             0x00048098"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0xFFFFFFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print RBIF_CONT_ACK_CMD PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.long 0 0.--31. 1  "[31 : 0]   RBIF_CONT_ACK_CMD                   = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00048098$ PER_TESLA9X45_Part5.per -queue RBIF_CONT_ACK_CMD"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0004809C
tree " RBIF_CONT_NACK_CMD [C]                                            0x0004809C"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0xFFFFFFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print RBIF_CONT_NACK_CMD PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.long 0 0.--31. 1  "[31 : 0]   RBIF_CONT_NACK_CMD                  = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0004809C$ PER_TESLA9X45_Part5.per -queue RBIF_CONT_NACK_CMD"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x000480A0
tree " RBCPR_RESULT_0 [R]                                                0x000480A0"
  group.long 0x0--0x3
   textline "POR 0x00080000    MASK = 0x000FFFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print RBCPR_RESULT_0 PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   19.          "[ 19 ]     BUSY                                = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   18.          "[ 18 ]     ERROR_LT_0                          = " "0x00 (?),0x01 (?)"
   textline ""
   hexmask.long.word 0 6.--17. 1  "[17 : 6]   ERROR                               = "
   textline ""
   bitfld.long 0x0   2.--5.       "[5 : 2]    ERROR_STEPS                         = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?),0x08 (?),0x09 (?),0x0A (?),0x0B (?),0x0C (?),0x0D (?),0x0E (?),0x0F (?)"
   textline ""
   bitfld.long 0x0   1.           "[ 1 ]      STEP_UP                             = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   0.           "[ 0 ]      STEP_DN                             = " "0x00 (?),0x01 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x000480A0$ PER_TESLA9X45_Part5.per -queue RBCPR_RESULT_0"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x000480A4
tree " RBCPR_RESULT_1 [R]                                                0x000480A4"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x000FFFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print RBCPR_RESULT_1 PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   13.--19.     "[19 : 13]  SENSOR_SLOW                         = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?),0x08 (?),0x09 (?),0x0A (?),0x0B (?),0x0C (?),0x0D (?),0x0E (?),0x0F (?),0x10 (?),0x11 (?),0x12 (?),0x13 (?),0x14 (?),0x15 (?),0x16 (?),0x17 (?),0x18 (?),0x19 (?),0x1A (?),0x1B (?),0x1C (?),0x1D (?),0x1E (?),0x1F (?),0x20 (?),0x21 (?),0x22 (?),0x23 (?),0x24 (?),0x25 (?),0x26 (?),0x27 (?),0x28 (?),0x29 (?),0x2A (?),0x2B (?),0x2C (?),0x2D (?),0x2E (?),0x2F (?),0x30 (?),0x31 (?),0x32 (?),0x33 (?),0x34 (?),0x35 (?),0x36 (?),0x37 (?),0x38 (?),0x39 (?),0x3A (?),0x3B (?),0x3C (?),0x3D (?),0x3E (?),0x3F (?),0x40 (?),0x41 (?),0x42 (?),0x43 (?),0x44 (?),0x45 (?),0x46 (?),0x47 (?),0x48 (?),0x49 (?),0x4A (?),0x4B (?),0x4C (?),0x4D (?),0x4E (?),0x4F (?),0x50 (?),0x51 (?),0x52 (?),0x53 (?),0x54 (?),0x55 (?),0x56 (?),0x57 (?),0x58 (?),0x59 (?),0x5A (?),0x5B (?),0x5C (?),0x5D (?),0x5E (?),0x5F (?),0x60 (?),0x61 (?),0x62 (?),0x63 (?),0x64 (?),0x65 (?),0x66 (?),0x67 (?),0x68 (?),0x69 (?),0x6A (?),0x6B (?),0x6C (?),0x6D (?),0x6E (?),0x6F (?),0x70 (?),0x71 (?),0x72 (?),0x73 (?),0x74 (?),0x75 (?),0x76 (?),0x77 (?),0x78 (?),0x79 (?),0x7A (?),0x7B (?),0x7C (?),0x7D (?),0x7E (?),0x7F (?)"
   textline ""
   bitfld.long 0x0   10.--12.     "[12 : 10]  SEL_SLOW                            = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?)"
   textline ""
   bitfld.long 0x0   3.--9.       "[9 : 3]    SENSOR_FAST                         = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?),0x08 (?),0x09 (?),0x0A (?),0x0B (?),0x0C (?),0x0D (?),0x0E (?),0x0F (?),0x10 (?),0x11 (?),0x12 (?),0x13 (?),0x14 (?),0x15 (?),0x16 (?),0x17 (?),0x18 (?),0x19 (?),0x1A (?),0x1B (?),0x1C (?),0x1D (?),0x1E (?),0x1F (?),0x20 (?),0x21 (?),0x22 (?),0x23 (?),0x24 (?),0x25 (?),0x26 (?),0x27 (?),0x28 (?),0x29 (?),0x2A (?),0x2B (?),0x2C (?),0x2D (?),0x2E (?),0x2F (?),0x30 (?),0x31 (?),0x32 (?),0x33 (?),0x34 (?),0x35 (?),0x36 (?),0x37 (?),0x38 (?),0x39 (?),0x3A (?),0x3B (?),0x3C (?),0x3D (?),0x3E (?),0x3F (?),0x40 (?),0x41 (?),0x42 (?),0x43 (?),0x44 (?),0x45 (?),0x46 (?),0x47 (?),0x48 (?),0x49 (?),0x4A (?),0x4B (?),0x4C (?),0x4D (?),0x4E (?),0x4F (?),0x50 (?),0x51 (?),0x52 (?),0x53 (?),0x54 (?),0x55 (?),0x56 (?),0x57 (?),0x58 (?),0x59 (?),0x5A (?),0x5B (?),0x5C (?),0x5D (?),0x5E (?),0x5F (?),0x60 (?),0x61 (?),0x62 (?),0x63 (?),0x64 (?),0x65 (?),0x66 (?),0x67 (?),0x68 (?),0x69 (?),0x6A (?),0x6B (?),0x6C (?),0x6D (?),0x6E (?),0x6F (?),0x70 (?),0x71 (?),0x72 (?),0x73 (?),0x74 (?),0x75 (?),0x76 (?),0x77 (?),0x78 (?),0x79 (?),0x7A (?),0x7B (?),0x7C (?),0x7D (?),0x7E (?),0x7F (?)"
   textline ""
   bitfld.long 0x0   0.--2.       "[2 : 0]    SEL_FAST                            = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x000480A4$ PER_TESLA9X45_Part5.per -queue RBCPR_RESULT_1"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00048100
tree " RBIF_IRQ_EN_0 [RW]                                                0x00048100"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x0000007F    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print RBIF_IRQ_EN_0 PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   6.           "[ 6 ]      CLAMP_CHANGE_WHILE_BUSY_EN          = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   5.           "[ 5 ]      MAX_FLAG_EN                         = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   4.           "[ 4 ]      UP_FLAG_EN                          = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   3.           "[ 3 ]      MID_FLAG_EN                         = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   2.           "[ 2 ]      DOWN_FLAG_EN                        = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   1.           "[ 1 ]      MIN_FLAG_EN                         = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   0.           "[ 0 ]      RBCPR_DONE_EN                       = " "0x00 (?),0x01 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00048100$ PER_TESLA9X45_Part5.per -queue RBIF_IRQ_EN_0"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00048104
tree " RBIF_IRQ_EN_1 [RW]                                                0x00048104"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x0000007F    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print RBIF_IRQ_EN_1 PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   6.           "[ 6 ]      CLAMP_CHANGE_WHILE_BUSY_EN          = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   5.           "[ 5 ]      MAX_FLAG_EN                         = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   4.           "[ 4 ]      UP_FLAG_EN                          = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   3.           "[ 3 ]      MID_FLAG_EN                         = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   2.           "[ 2 ]      DOWN_FLAG_EN                        = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   1.           "[ 1 ]      MIN_FLAG_EN                         = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   0.           "[ 0 ]      RBCPR_DONE_EN                       = " "0x00 (?),0x01 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00048104$ PER_TESLA9X45_Part5.per -queue RBIF_IRQ_EN_1"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00048108
tree " RBIF_IRQ_EN_2 [RW]                                                0x00048108"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x0000007F    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print RBIF_IRQ_EN_2 PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   6.           "[ 6 ]      CLAMP_CHANGE_WHILE_BUSY_EN          = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   5.           "[ 5 ]      MAX_FLAG_EN                         = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   4.           "[ 4 ]      UP_FLAG_EN                          = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   3.           "[ 3 ]      MID_FLAG_EN                         = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   2.           "[ 2 ]      DOWN_FLAG_EN                        = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   1.           "[ 1 ]      MIN_FLAG_EN                         = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   0.           "[ 0 ]      RBCPR_DONE_EN                       = " "0x00 (?),0x01 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00048108$ PER_TESLA9X45_Part5.per -queue RBIF_IRQ_EN_2"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00048110
tree " RBIF_IRQ_CLEAR [C]                                                0x00048110"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x0000007F    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print RBIF_IRQ_CLEAR PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   6.           "[ 6 ]      CLAMP_CHANGE_WHILE_BUSY_CLEAR       = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   5.           "[ 5 ]      MAX_FLAG_CLEAR                      = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   4.           "[ 4 ]      UP_FLAG_CLEAR                       = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   3.           "[ 3 ]      MID_FLAG_CLEAR                      = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   2.           "[ 2 ]      DOWN_FLAG_CLEAR                     = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   1.           "[ 1 ]      MIN_FLAG_CLEAR                      = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   0.           "[ 0 ]      RBCPR_DONE_CLEAR                    = " "0x00 (?),0x01 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00048110$ PER_TESLA9X45_Part5.per -queue RBIF_IRQ_CLEAR"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00048114
tree " RBIF_IRQ_STATUS [R]                                               0x00048114"
  group.long 0x0--0x3
   textline "POR 0x00000040    MASK = 0x0000007F    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print RBIF_IRQ_STATUS PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   6.           "[ 6 ]      CLAMP_CHANGE_WHILE_BUSY             = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   5.           "[ 5 ]      MAX_FLAG                            = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   4.           "[ 4 ]      UP_FLAG                             = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   3.           "[ 3 ]      MID_FLAG                            = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   2.           "[ 2 ]      DOWN_FLAG                           = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   1.           "[ 1 ]      MIN_FLAG                            = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   0.           "[ 0 ]      RBCPR_DONE                          = " "0x00 (?),0x01 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00048114$ PER_TESLA9X45_Part5.per -queue RBIF_IRQ_STATUS"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00048118
tree " RBCPR_QUOT_AVG [R]                                                0x00048118"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x3FFFFFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print RBCPR_QUOT_AVG PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.long 0 8.--29. 1  "[29 : 8]   QUOT_SUM                            = "
   textline ""
   hexmask.long.byte 0 0.--7. 1   "[7 : 0]    SENSOR_SUM                          = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00048118$ PER_TESLA9X45_Part5.per -queue RBCPR_QUOT_AVG"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0004811C
tree " RBCPR_DEBUG0 [R]                                                  0x0004811C"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0xFFFFFFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print RBCPR_DEBUG0 PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.word 0 21.--31. 1 "[31 : 21]  SCLK_CNT1                           = "
   textline ""
   hexmask.long.word 0 10.--20. 1 "[20 : 10]  SCLK_CNT0                           = "
   textline ""
   bitfld.long 0x0   8.--9.       "[9 : 8]    SCLK_CNT_FAIL                       = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?)"
   textline ""
   bitfld.long 0x0   6.--7.       "[7 : 6]    DBG_END_OF_CHAIN_DREG               = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?)"
   textline ""
   bitfld.long 0x0   0.--5.       "[5 : 0]    DBG_SHIFT_RING                      = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?),0x08 (?),0x09 (?),0x0A (?),0x0B (?),0x0C (?),0x0D (?),0x0E (?),0x0F (?),0x10 (?),0x11 (?),0x12 (?),0x13 (?),0x14 (?),0x15 (?),0x16 (?),0x17 (?),0x18 (?),0x19 (?),0x1A (?),0x1B (?),0x1C (?),0x1D (?),0x1E (?),0x1F (?),0x20 (?),0x21 (?),0x22 (?),0x23 (?),0x24 (?),0x25 (?),0x26 (?),0x27 (?),0x28 (?),0x29 (?),0x2A (?),0x2B (?),0x2C (?),0x2D (?),0x2E (?),0x2F (?),0x30 (?),0x31 (?),0x32 (?),0x33 (?),0x34 (?),0x35 (?),0x36 (?),0x37 (?),0x38 (?),0x39 (?),0x3A (?),0x3B (?),0x3C (?),0x3D (?),0x3E (?),0x3F (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0004811C$ PER_TESLA9X45_Part5.per -queue RBCPR_DEBUG0"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00048120
tree " RBCPR_DEBUG1 [R]                                                  0x00048120"
  group.long 0x0--0x3
   textline "POR 0xA0FFF000    MASK = 0xFFFFFFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print RBCPR_DEBUG1 PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   31.          "[ 31 ]     DBG_END_OF_CHAIN_ENA                = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   30.          "[ 30 ]     DBG_VALID                           = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   29.          "[ 29 ]     DBG_END_OF_CHAIN_MODE               = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   27.--28.     "[28 : 27]  DBG_END_OF_CHAIN_DATA               = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?)"
   textline ""
   bitfld.long 0x0   24.--26.     "[26 : 24]  DBG_FSM_STATE                       = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?)"
   textline ""
   hexmask.long.word 0 12.--23. 1 "[23 : 12]  QUOT_SLOW                           = "
   textline ""
   hexmask.long.word 0 0.--11. 1  "[11 : 0]   QUOT_FAST                           = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00048120$ PER_TESLA9X45_Part5.per -queue RBCPR_DEBUG1"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00048124
tree " RBCPR_DEBUG2 [R]                                                  0x00048124"
  group.long 0x0--0x3
   textline "POR 0x00000032    MASK = 0xFFFFFFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print RBCPR_DEBUG2 PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   31.          "[ 31 ]     DBG_SEL_DONE                        = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   30.          "[ 30 ]     DBG_SENSOR_DONE                     = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   23.--29.     "[29 : 23]  DBG_SENSOR                          = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?),0x08 (?),0x09 (?),0x0A (?),0x0B (?),0x0C (?),0x0D (?),0x0E (?),0x0F (?),0x10 (?),0x11 (?),0x12 (?),0x13 (?),0x14 (?),0x15 (?),0x16 (?),0x17 (?),0x18 (?),0x19 (?),0x1A (?),0x1B (?),0x1C (?),0x1D (?),0x1E (?),0x1F (?),0x20 (?),0x21 (?),0x22 (?),0x23 (?),0x24 (?),0x25 (?),0x26 (?),0x27 (?),0x28 (?),0x29 (?),0x2A (?),0x2B (?),0x2C (?),0x2D (?),0x2E (?),0x2F (?),0x30 (?),0x31 (?),0x32 (?),0x33 (?),0x34 (?),0x35 (?),0x36 (?),0x37 (?),0x38 (?),0x39 (?),0x3A (?),0x3B (?),0x3C (?),0x3D (?),0x3E (?),0x3F (?),0x40 (?),0x41 (?),0x42 (?),0x43 (?),0x44 (?),0x45 (?),0x46 (?),0x47 (?),0x48 (?),0x49 (?),0x4A (?),0x4B (?),0x4C (?),0x4D (?),0x4E (?),0x4F (?),0x50 (?),0x51 (?),0x52 (?),0x53 (?),0x54 (?),0x55 (?),0x56 (?),0x57 (?),0x58 (?),0x59 (?),0x5A (?),0x5B (?),0x5C (?),0x5D (?),0x5E (?),0x5F (?),0x60 (?),0x61 (?),0x62 (?),0x63 (?),0x64 (?),0x65 (?),0x66 (?),0x67 (?),0x68 (?),0x69 (?),0x6A (?),0x6B (?),0x6C (?),0x6D (?),0x6E (?),0x6F (?),0x70 (?),0x71 (?),0x72 (?),0x73 (?),0x74 (?),0x75 (?),0x76 (?),0x77 (?),0x78 (?),0x79 (?),0x7A (?),0x7B (?),0x7C (?),0x7D (?),0x7E (?),0x7F (?)"
   textline ""
   bitfld.long 0x0   20.--22.     "[22 : 20]  DBG_SEL                             = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?)"
   textline ""
   hexmask.long.word 0 8.--19. 1  "[19 : 8]   DBG_QUOT                            = "
   textline ""
   hexmask.long.byte 0 0.--7. 1   "[7 : 0]    DBG_STEP_QUOT                       = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00048124$ PER_TESLA9X45_Part5.per -queue RBCPR_DEBUG2"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00048128
tree " RBCPR_BIST_MINMAX [RW]                                            0x00048128"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x00FFFFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print RBCPR_BIST_MINMAX PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.word 0 12.--23. 1 "[23 : 12]  BIST_QUOT_ABSMIN                    = "
   textline ""
   hexmask.long.word 0 0.--11. 1  "[11 : 0]   BIST_QUOT_ABSMAX                    = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00048128$ PER_TESLA9X45_Part5.per -queue RBCPR_BIST_MINMAX"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0004812C
tree " RBCPR_BIST_RESULT [R]                                             0x0004812C"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x0001FFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print RBCPR_BIST_RESULT PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   16.          "[ 16 ]     SENSOR_ELAB_DONE                    = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   15.          "[ 15 ]     BIST_FAIL                           = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   12.--14.     "[14 : 12]  BIST_FAIL_LASTSEL                   = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?)"
   textline ""
   hexmask.long.word 0 0.--11. 1  "[11 : 0]   BIST_FAIL_LASTQUOT                  = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0004812C$ PER_TESLA9X45_Part5.per -queue RBCPR_BIST_RESULT"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00048130
tree " RBCPR_BIST_FAIL_MAP0 [R]                                          0x00048130"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0xFFFFFFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print RBCPR_BIST_FAIL_MAP0 PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.long 0 0.--31. 1  "[31 : 0]   BIST_FAIL_MAP                       = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00048130$ PER_TESLA9X45_Part5.per -queue RBCPR_BIST_FAIL_MAP0"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00048134
tree " RBCPR_BIST_FAIL_MAP1 [R]                                          0x00048134"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0xFFFFFFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print RBCPR_BIST_FAIL_MAP1 PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.long 0 0.--31. 1  "[31 : 0]   BIST_FAIL_MAP                       = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00048134$ PER_TESLA9X45_Part5.per -queue RBCPR_BIST_FAIL_MAP1"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00048138
tree " RBCPR_BIST_FAIL_MAP2 [R]                                          0x00048138"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0xFFFFFFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print RBCPR_BIST_FAIL_MAP2 PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.long 0 0.--31. 1  "[31 : 0]   BIST_FAIL_MAP                       = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00048138$ PER_TESLA9X45_Part5.per -queue RBCPR_BIST_FAIL_MAP2"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0004813C
tree " RBCPR_BIST_FAIL_MAP3 [R]                                          0x0004813C"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0xFFFFFFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print RBCPR_BIST_FAIL_MAP3 PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.long 0 0.--31. 1  "[31 : 0]   BIST_FAIL_MAP                       = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0004813C$ PER_TESLA9X45_Part5.per -queue RBCPR_BIST_FAIL_MAP3"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00048140
tree " RBCPR_LOG_0 [R]                                                   0x00048140"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0xFFFFF7FF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print RBCPR_LOG_0 PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.word 0 18.--31. 1 "[31 : 18]  MID_COUNT                           = "
   textline ""
   bitfld.long 0x0   12.--17.     "[17 : 12]  MX_VLEVEL                           = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?),0x08 (?),0x09 (?),0x0A (?),0x0B (?),0x0C (?),0x0D (?),0x0E (?),0x0F (?),0x10 (?),0x11 (?),0x12 (?),0x13 (?),0x14 (?),0x15 (?),0x16 (?),0x17 (?),0x18 (?),0x19 (?),0x1A (?),0x1B (?),0x1C (?),0x1D (?),0x1E (?),0x1F (?),0x20 (?),0x21 (?),0x22 (?),0x23 (?),0x24 (?),0x25 (?),0x26 (?),0x27 (?),0x28 (?),0x29 (?),0x2A (?),0x2B (?),0x2C (?),0x2D (?),0x2E (?),0x2F (?),0x30 (?),0x31 (?),0x32 (?),0x33 (?),0x34 (?),0x35 (?),0x36 (?),0x37 (?),0x38 (?),0x39 (?),0x3A (?),0x3B (?),0x3C (?),0x3D (?),0x3E (?),0x3F (?)"
   textline ""
   bitfld.long 0x0   10.          "[ 10 ]     MAX_FLAG                            = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   9.           "[ 9 ]      UP_FLAG                             = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   8.           "[ 8 ]      MID_FLAG                            = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   7.           "[ 7 ]      DOWN_FLAG                           = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   6.           "[ 6 ]      MIN_FLAG                            = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   0.--5.       "[5 : 0]    VLEVEL                              = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?),0x08 (?),0x09 (?),0x0A (?),0x0B (?),0x0C (?),0x0D (?),0x0E (?),0x0F (?),0x10 (?),0x11 (?),0x12 (?),0x13 (?),0x14 (?),0x15 (?),0x16 (?),0x17 (?),0x18 (?),0x19 (?),0x1A (?),0x1B (?),0x1C (?),0x1D (?),0x1E (?),0x1F (?),0x20 (?),0x21 (?),0x22 (?),0x23 (?),0x24 (?),0x25 (?),0x26 (?),0x27 (?),0x28 (?),0x29 (?),0x2A (?),0x2B (?),0x2C (?),0x2D (?),0x2E (?),0x2F (?),0x30 (?),0x31 (?),0x32 (?),0x33 (?),0x34 (?),0x35 (?),0x36 (?),0x37 (?),0x38 (?),0x39 (?),0x3A (?),0x3B (?),0x3C (?),0x3D (?),0x3E (?),0x3F (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00048140$ PER_TESLA9X45_Part5.per -queue RBCPR_LOG_0"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00048144
tree " RBCPR_LOG_1 [R]                                                   0x00048144"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0xFFFFF7FF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print RBCPR_LOG_1 PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.word 0 18.--31. 1 "[31 : 18]  MID_COUNT                           = "
   textline ""
   bitfld.long 0x0   12.--17.     "[17 : 12]  MX_VLEVEL                           = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?),0x08 (?),0x09 (?),0x0A (?),0x0B (?),0x0C (?),0x0D (?),0x0E (?),0x0F (?),0x10 (?),0x11 (?),0x12 (?),0x13 (?),0x14 (?),0x15 (?),0x16 (?),0x17 (?),0x18 (?),0x19 (?),0x1A (?),0x1B (?),0x1C (?),0x1D (?),0x1E (?),0x1F (?),0x20 (?),0x21 (?),0x22 (?),0x23 (?),0x24 (?),0x25 (?),0x26 (?),0x27 (?),0x28 (?),0x29 (?),0x2A (?),0x2B (?),0x2C (?),0x2D (?),0x2E (?),0x2F (?),0x30 (?),0x31 (?),0x32 (?),0x33 (?),0x34 (?),0x35 (?),0x36 (?),0x37 (?),0x38 (?),0x39 (?),0x3A (?),0x3B (?),0x3C (?),0x3D (?),0x3E (?),0x3F (?)"
   textline ""
   bitfld.long 0x0   10.          "[ 10 ]     MAX_FLAG                            = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   9.           "[ 9 ]      UP_FLAG                             = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   8.           "[ 8 ]      MID_FLAG                            = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   7.           "[ 7 ]      DOWN_FLAG                           = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   6.           "[ 6 ]      MIN_FLAG                            = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   0.--5.       "[5 : 0]    VLEVEL                              = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?),0x08 (?),0x09 (?),0x0A (?),0x0B (?),0x0C (?),0x0D (?),0x0E (?),0x0F (?),0x10 (?),0x11 (?),0x12 (?),0x13 (?),0x14 (?),0x15 (?),0x16 (?),0x17 (?),0x18 (?),0x19 (?),0x1A (?),0x1B (?),0x1C (?),0x1D (?),0x1E (?),0x1F (?),0x20 (?),0x21 (?),0x22 (?),0x23 (?),0x24 (?),0x25 (?),0x26 (?),0x27 (?),0x28 (?),0x29 (?),0x2A (?),0x2B (?),0x2C (?),0x2D (?),0x2E (?),0x2F (?),0x30 (?),0x31 (?),0x32 (?),0x33 (?),0x34 (?),0x35 (?),0x36 (?),0x37 (?),0x38 (?),0x39 (?),0x3A (?),0x3B (?),0x3C (?),0x3D (?),0x3E (?),0x3F (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00048144$ PER_TESLA9X45_Part5.per -queue RBCPR_LOG_1"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00048148
tree " RBCPR_LOG_2 [R]                                                   0x00048148"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0xFFFFF7FF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print RBCPR_LOG_2 PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.word 0 18.--31. 1 "[31 : 18]  MID_COUNT                           = "
   textline ""
   bitfld.long 0x0   12.--17.     "[17 : 12]  MX_VLEVEL                           = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?),0x08 (?),0x09 (?),0x0A (?),0x0B (?),0x0C (?),0x0D (?),0x0E (?),0x0F (?),0x10 (?),0x11 (?),0x12 (?),0x13 (?),0x14 (?),0x15 (?),0x16 (?),0x17 (?),0x18 (?),0x19 (?),0x1A (?),0x1B (?),0x1C (?),0x1D (?),0x1E (?),0x1F (?),0x20 (?),0x21 (?),0x22 (?),0x23 (?),0x24 (?),0x25 (?),0x26 (?),0x27 (?),0x28 (?),0x29 (?),0x2A (?),0x2B (?),0x2C (?),0x2D (?),0x2E (?),0x2F (?),0x30 (?),0x31 (?),0x32 (?),0x33 (?),0x34 (?),0x35 (?),0x36 (?),0x37 (?),0x38 (?),0x39 (?),0x3A (?),0x3B (?),0x3C (?),0x3D (?),0x3E (?),0x3F (?)"
   textline ""
   bitfld.long 0x0   10.          "[ 10 ]     MAX_FLAG                            = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   9.           "[ 9 ]      UP_FLAG                             = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   8.           "[ 8 ]      MID_FLAG                            = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   7.           "[ 7 ]      DOWN_FLAG                           = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   6.           "[ 6 ]      MIN_FLAG                            = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   0.--5.       "[5 : 0]    VLEVEL                              = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?),0x08 (?),0x09 (?),0x0A (?),0x0B (?),0x0C (?),0x0D (?),0x0E (?),0x0F (?),0x10 (?),0x11 (?),0x12 (?),0x13 (?),0x14 (?),0x15 (?),0x16 (?),0x17 (?),0x18 (?),0x19 (?),0x1A (?),0x1B (?),0x1C (?),0x1D (?),0x1E (?),0x1F (?),0x20 (?),0x21 (?),0x22 (?),0x23 (?),0x24 (?),0x25 (?),0x26 (?),0x27 (?),0x28 (?),0x29 (?),0x2A (?),0x2B (?),0x2C (?),0x2D (?),0x2E (?),0x2F (?),0x30 (?),0x31 (?),0x32 (?),0x33 (?),0x34 (?),0x35 (?),0x36 (?),0x37 (?),0x38 (?),0x39 (?),0x3A (?),0x3B (?),0x3C (?),0x3D (?),0x3E (?),0x3F (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00048148$ PER_TESLA9X45_Part5.per -queue RBCPR_LOG_2"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0004814C
tree " RBCPR_LOG_3 [R]                                                   0x0004814C"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0xFFFFF7FF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print RBCPR_LOG_3 PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.word 0 18.--31. 1 "[31 : 18]  MID_COUNT                           = "
   textline ""
   bitfld.long 0x0   12.--17.     "[17 : 12]  MX_VLEVEL                           = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?),0x08 (?),0x09 (?),0x0A (?),0x0B (?),0x0C (?),0x0D (?),0x0E (?),0x0F (?),0x10 (?),0x11 (?),0x12 (?),0x13 (?),0x14 (?),0x15 (?),0x16 (?),0x17 (?),0x18 (?),0x19 (?),0x1A (?),0x1B (?),0x1C (?),0x1D (?),0x1E (?),0x1F (?),0x20 (?),0x21 (?),0x22 (?),0x23 (?),0x24 (?),0x25 (?),0x26 (?),0x27 (?),0x28 (?),0x29 (?),0x2A (?),0x2B (?),0x2C (?),0x2D (?),0x2E (?),0x2F (?),0x30 (?),0x31 (?),0x32 (?),0x33 (?),0x34 (?),0x35 (?),0x36 (?),0x37 (?),0x38 (?),0x39 (?),0x3A (?),0x3B (?),0x3C (?),0x3D (?),0x3E (?),0x3F (?)"
   textline ""
   bitfld.long 0x0   10.          "[ 10 ]     MAX_FLAG                            = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   9.           "[ 9 ]      UP_FLAG                             = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   8.           "[ 8 ]      MID_FLAG                            = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   7.           "[ 7 ]      DOWN_FLAG                           = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   6.           "[ 6 ]      MIN_FLAG                            = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   0.--5.       "[5 : 0]    VLEVEL                              = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?),0x08 (?),0x09 (?),0x0A (?),0x0B (?),0x0C (?),0x0D (?),0x0E (?),0x0F (?),0x10 (?),0x11 (?),0x12 (?),0x13 (?),0x14 (?),0x15 (?),0x16 (?),0x17 (?),0x18 (?),0x19 (?),0x1A (?),0x1B (?),0x1C (?),0x1D (?),0x1E (?),0x1F (?),0x20 (?),0x21 (?),0x22 (?),0x23 (?),0x24 (?),0x25 (?),0x26 (?),0x27 (?),0x28 (?),0x29 (?),0x2A (?),0x2B (?),0x2C (?),0x2D (?),0x2E (?),0x2F (?),0x30 (?),0x31 (?),0x32 (?),0x33 (?),0x34 (?),0x35 (?),0x36 (?),0x37 (?),0x38 (?),0x39 (?),0x3A (?),0x3B (?),0x3C (?),0x3D (?),0x3E (?),0x3F (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0004814C$ PER_TESLA9X45_Part5.per -queue RBCPR_LOG_3"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00048150
tree " RBCPR_LOG_4 [R]                                                   0x00048150"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0xFFFFF7FF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print RBCPR_LOG_4 PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.word 0 18.--31. 1 "[31 : 18]  MID_COUNT                           = "
   textline ""
   bitfld.long 0x0   12.--17.     "[17 : 12]  MX_VLEVEL                           = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?),0x08 (?),0x09 (?),0x0A (?),0x0B (?),0x0C (?),0x0D (?),0x0E (?),0x0F (?),0x10 (?),0x11 (?),0x12 (?),0x13 (?),0x14 (?),0x15 (?),0x16 (?),0x17 (?),0x18 (?),0x19 (?),0x1A (?),0x1B (?),0x1C (?),0x1D (?),0x1E (?),0x1F (?),0x20 (?),0x21 (?),0x22 (?),0x23 (?),0x24 (?),0x25 (?),0x26 (?),0x27 (?),0x28 (?),0x29 (?),0x2A (?),0x2B (?),0x2C (?),0x2D (?),0x2E (?),0x2F (?),0x30 (?),0x31 (?),0x32 (?),0x33 (?),0x34 (?),0x35 (?),0x36 (?),0x37 (?),0x38 (?),0x39 (?),0x3A (?),0x3B (?),0x3C (?),0x3D (?),0x3E (?),0x3F (?)"
   textline ""
   bitfld.long 0x0   10.          "[ 10 ]     MAX_FLAG                            = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   9.           "[ 9 ]      UP_FLAG                             = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   8.           "[ 8 ]      MID_FLAG                            = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   7.           "[ 7 ]      DOWN_FLAG                           = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   6.           "[ 6 ]      MIN_FLAG                            = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   0.--5.       "[5 : 0]    VLEVEL                              = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?),0x08 (?),0x09 (?),0x0A (?),0x0B (?),0x0C (?),0x0D (?),0x0E (?),0x0F (?),0x10 (?),0x11 (?),0x12 (?),0x13 (?),0x14 (?),0x15 (?),0x16 (?),0x17 (?),0x18 (?),0x19 (?),0x1A (?),0x1B (?),0x1C (?),0x1D (?),0x1E (?),0x1F (?),0x20 (?),0x21 (?),0x22 (?),0x23 (?),0x24 (?),0x25 (?),0x26 (?),0x27 (?),0x28 (?),0x29 (?),0x2A (?),0x2B (?),0x2C (?),0x2D (?),0x2E (?),0x2F (?),0x30 (?),0x31 (?),0x32 (?),0x33 (?),0x34 (?),0x35 (?),0x36 (?),0x37 (?),0x38 (?),0x39 (?),0x3A (?),0x3B (?),0x3C (?),0x3D (?),0x3E (?),0x3F (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00048150$ PER_TESLA9X45_Part5.per -queue RBCPR_LOG_4"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00048154
tree " RBCPR_LOG_5 [R]                                                   0x00048154"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0xFFFFF7FF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print RBCPR_LOG_5 PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.word 0 18.--31. 1 "[31 : 18]  MID_COUNT                           = "
   textline ""
   bitfld.long 0x0   12.--17.     "[17 : 12]  MX_VLEVEL                           = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?),0x08 (?),0x09 (?),0x0A (?),0x0B (?),0x0C (?),0x0D (?),0x0E (?),0x0F (?),0x10 (?),0x11 (?),0x12 (?),0x13 (?),0x14 (?),0x15 (?),0x16 (?),0x17 (?),0x18 (?),0x19 (?),0x1A (?),0x1B (?),0x1C (?),0x1D (?),0x1E (?),0x1F (?),0x20 (?),0x21 (?),0x22 (?),0x23 (?),0x24 (?),0x25 (?),0x26 (?),0x27 (?),0x28 (?),0x29 (?),0x2A (?),0x2B (?),0x2C (?),0x2D (?),0x2E (?),0x2F (?),0x30 (?),0x31 (?),0x32 (?),0x33 (?),0x34 (?),0x35 (?),0x36 (?),0x37 (?),0x38 (?),0x39 (?),0x3A (?),0x3B (?),0x3C (?),0x3D (?),0x3E (?),0x3F (?)"
   textline ""
   bitfld.long 0x0   10.          "[ 10 ]     MAX_FLAG                            = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   9.           "[ 9 ]      UP_FLAG                             = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   8.           "[ 8 ]      MID_FLAG                            = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   7.           "[ 7 ]      DOWN_FLAG                           = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   6.           "[ 6 ]      MIN_FLAG                            = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   0.--5.       "[5 : 0]    VLEVEL                              = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?),0x08 (?),0x09 (?),0x0A (?),0x0B (?),0x0C (?),0x0D (?),0x0E (?),0x0F (?),0x10 (?),0x11 (?),0x12 (?),0x13 (?),0x14 (?),0x15 (?),0x16 (?),0x17 (?),0x18 (?),0x19 (?),0x1A (?),0x1B (?),0x1C (?),0x1D (?),0x1E (?),0x1F (?),0x20 (?),0x21 (?),0x22 (?),0x23 (?),0x24 (?),0x25 (?),0x26 (?),0x27 (?),0x28 (?),0x29 (?),0x2A (?),0x2B (?),0x2C (?),0x2D (?),0x2E (?),0x2F (?),0x30 (?),0x31 (?),0x32 (?),0x33 (?),0x34 (?),0x35 (?),0x36 (?),0x37 (?),0x38 (?),0x39 (?),0x3A (?),0x3B (?),0x3C (?),0x3D (?),0x3E (?),0x3F (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00048154$ PER_TESLA9X45_Part5.per -queue RBCPR_LOG_5"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00048158
tree " RBCPR_LOG_6 [R]                                                   0x00048158"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0xFFFFF7FF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print RBCPR_LOG_6 PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.word 0 18.--31. 1 "[31 : 18]  MID_COUNT                           = "
   textline ""
   bitfld.long 0x0   12.--17.     "[17 : 12]  MX_VLEVEL                           = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?),0x08 (?),0x09 (?),0x0A (?),0x0B (?),0x0C (?),0x0D (?),0x0E (?),0x0F (?),0x10 (?),0x11 (?),0x12 (?),0x13 (?),0x14 (?),0x15 (?),0x16 (?),0x17 (?),0x18 (?),0x19 (?),0x1A (?),0x1B (?),0x1C (?),0x1D (?),0x1E (?),0x1F (?),0x20 (?),0x21 (?),0x22 (?),0x23 (?),0x24 (?),0x25 (?),0x26 (?),0x27 (?),0x28 (?),0x29 (?),0x2A (?),0x2B (?),0x2C (?),0x2D (?),0x2E (?),0x2F (?),0x30 (?),0x31 (?),0x32 (?),0x33 (?),0x34 (?),0x35 (?),0x36 (?),0x37 (?),0x38 (?),0x39 (?),0x3A (?),0x3B (?),0x3C (?),0x3D (?),0x3E (?),0x3F (?)"
   textline ""
   bitfld.long 0x0   10.          "[ 10 ]     MAX_FLAG                            = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   9.           "[ 9 ]      UP_FLAG                             = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   8.           "[ 8 ]      MID_FLAG                            = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   7.           "[ 7 ]      DOWN_FLAG                           = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   6.           "[ 6 ]      MIN_FLAG                            = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   0.--5.       "[5 : 0]    VLEVEL                              = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?),0x08 (?),0x09 (?),0x0A (?),0x0B (?),0x0C (?),0x0D (?),0x0E (?),0x0F (?),0x10 (?),0x11 (?),0x12 (?),0x13 (?),0x14 (?),0x15 (?),0x16 (?),0x17 (?),0x18 (?),0x19 (?),0x1A (?),0x1B (?),0x1C (?),0x1D (?),0x1E (?),0x1F (?),0x20 (?),0x21 (?),0x22 (?),0x23 (?),0x24 (?),0x25 (?),0x26 (?),0x27 (?),0x28 (?),0x29 (?),0x2A (?),0x2B (?),0x2C (?),0x2D (?),0x2E (?),0x2F (?),0x30 (?),0x31 (?),0x32 (?),0x33 (?),0x34 (?),0x35 (?),0x36 (?),0x37 (?),0x38 (?),0x39 (?),0x3A (?),0x3B (?),0x3C (?),0x3D (?),0x3E (?),0x3F (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00048158$ PER_TESLA9X45_Part5.per -queue RBCPR_LOG_6"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0004815C
tree " RBCPR_LOG_7 [R]                                                   0x0004815C"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0xFFFFF7FF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print RBCPR_LOG_7 PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.word 0 18.--31. 1 "[31 : 18]  MID_COUNT                           = "
   textline ""
   bitfld.long 0x0   12.--17.     "[17 : 12]  MX_VLEVEL                           = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?),0x08 (?),0x09 (?),0x0A (?),0x0B (?),0x0C (?),0x0D (?),0x0E (?),0x0F (?),0x10 (?),0x11 (?),0x12 (?),0x13 (?),0x14 (?),0x15 (?),0x16 (?),0x17 (?),0x18 (?),0x19 (?),0x1A (?),0x1B (?),0x1C (?),0x1D (?),0x1E (?),0x1F (?),0x20 (?),0x21 (?),0x22 (?),0x23 (?),0x24 (?),0x25 (?),0x26 (?),0x27 (?),0x28 (?),0x29 (?),0x2A (?),0x2B (?),0x2C (?),0x2D (?),0x2E (?),0x2F (?),0x30 (?),0x31 (?),0x32 (?),0x33 (?),0x34 (?),0x35 (?),0x36 (?),0x37 (?),0x38 (?),0x39 (?),0x3A (?),0x3B (?),0x3C (?),0x3D (?),0x3E (?),0x3F (?)"
   textline ""
   bitfld.long 0x0   10.          "[ 10 ]     MAX_FLAG                            = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   9.           "[ 9 ]      UP_FLAG                             = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   8.           "[ 8 ]      MID_FLAG                            = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   7.           "[ 7 ]      DOWN_FLAG                           = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   6.           "[ 6 ]      MIN_FLAG                            = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   0.--5.       "[5 : 0]    VLEVEL                              = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?),0x08 (?),0x09 (?),0x0A (?),0x0B (?),0x0C (?),0x0D (?),0x0E (?),0x0F (?),0x10 (?),0x11 (?),0x12 (?),0x13 (?),0x14 (?),0x15 (?),0x16 (?),0x17 (?),0x18 (?),0x19 (?),0x1A (?),0x1B (?),0x1C (?),0x1D (?),0x1E (?),0x1F (?),0x20 (?),0x21 (?),0x22 (?),0x23 (?),0x24 (?),0x25 (?),0x26 (?),0x27 (?),0x28 (?),0x29 (?),0x2A (?),0x2B (?),0x2C (?),0x2D (?),0x2E (?),0x2F (?),0x30 (?),0x31 (?),0x32 (?),0x33 (?),0x34 (?),0x35 (?),0x36 (?),0x37 (?),0x38 (?),0x39 (?),0x3A (?),0x3B (?),0x3C (?),0x3D (?),0x3E (?),0x3F (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0004815C$ PER_TESLA9X45_Part5.per -queue RBCPR_LOG_7"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00048160
tree " RBCPR_HTOL_AGE [RW]                                               0x00048160"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x00000007    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print RBCPR_HTOL_AGE PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   2.           "[ 2 ]      CPR_AGE_DATA_STATUS                 = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   1.           "[ 1 ]      AGE_PAGE                            = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   0.           "[ 0 ]      HTOL_MODE                           = " "0x00 (?),0x01 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00048160$ PER_TESLA9X45_Part5.per -queue RBCPR_HTOL_AGE"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00070000
tree " MX_RBCPR_VERSION [R]                                              0x00070000"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0xFFFFFFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print MX_RBCPR_VERSION PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.long 0 0.--31. 1  "[31 : 0]   RBCPR_VERSION                       = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00070000$ PER_TESLA9X45_Part5.per -queue MX_RBCPR_VERSION"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00070020
tree " MX_RBCPR_SENSOR_MASK0 [RW]                                        0x00070020"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0xFFFFFFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print MX_RBCPR_SENSOR_MASK0 PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.long 0 0.--31. 1  "[31 : 0]   SENSOR_MASK                         = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00070020$ PER_TESLA9X45_Part5.per -queue MX_RBCPR_SENSOR_MASK0"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00070024
tree " MX_RBCPR_SENSOR_MASK1 [RW]                                        0x00070024"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0xFFFFFFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print MX_RBCPR_SENSOR_MASK1 PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.long 0 0.--31. 1  "[31 : 0]   SENSOR_MASK                         = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00070024$ PER_TESLA9X45_Part5.per -queue MX_RBCPR_SENSOR_MASK1"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00070028
tree " MX_RBCPR_SENSOR_MASK2 [RW]                                        0x00070028"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0xFFFFFFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print MX_RBCPR_SENSOR_MASK2 PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.long 0 0.--31. 1  "[31 : 0]   SENSOR_MASK                         = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00070028$ PER_TESLA9X45_Part5.per -queue MX_RBCPR_SENSOR_MASK2"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0007002C
tree " MX_RBCPR_SENSOR_MASK3 [RW]                                        0x0007002C"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0xFFFFFFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print MX_RBCPR_SENSOR_MASK3 PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.long 0 0.--31. 1  "[31 : 0]   SENSOR_MASK                         = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0007002C$ PER_TESLA9X45_Part5.per -queue MX_RBCPR_SENSOR_MASK3"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00070030
tree " MX_RBCPR_SENSOR_BYPASS0 [RW]                                      0x00070030"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0xFFFFFFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print MX_RBCPR_SENSOR_BYPASS0 PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.long 0 0.--31. 1  "[31 : 0]   SENSOR_BYPASS                       = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00070030$ PER_TESLA9X45_Part5.per -queue MX_RBCPR_SENSOR_BYPASS0"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00070034
tree " MX_RBCPR_SENSOR_BYPASS1 [RW]                                      0x00070034"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0xFFFFFFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print MX_RBCPR_SENSOR_BYPASS1 PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.long 0 0.--31. 1  "[31 : 0]   SENSOR_BYPASS                       = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00070034$ PER_TESLA9X45_Part5.per -queue MX_RBCPR_SENSOR_BYPASS1"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00070038
tree " MX_RBCPR_SENSOR_BYPASS2 [RW]                                      0x00070038"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0xFFFFFFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print MX_RBCPR_SENSOR_BYPASS2 PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.long 0 0.--31. 1  "[31 : 0]   SENSOR_BYPASS                       = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00070038$ PER_TESLA9X45_Part5.per -queue MX_RBCPR_SENSOR_BYPASS2"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0007003C
tree " MX_RBCPR_SENSOR_BYPASS3 [RW]                                      0x0007003C"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0xFFFFFFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print MX_RBCPR_SENSOR_BYPASS3 PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.long 0 0.--31. 1  "[31 : 0]   SENSOR_BYPASS                       = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0007003C$ PER_TESLA9X45_Part5.per -queue MX_RBCPR_SENSOR_BYPASS3"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00070040
tree " MX_RBIF_PMIC_ADDR [RW]                                            0x00070040"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x00C03C03    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print MX_RBIF_PMIC_ADDR PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   22.--23.     "[23 : 22]  RBIF_PMIC_MX_DATA_MSB               = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?)"
   textline ""
   bitfld.long 0x0   12.--13.     "[13 : 12]  RBIF_PMIC_MX_ADDR                   = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?)"
   textline ""
   bitfld.long 0x0   10.--11.     "[11 : 10]  RBIF_PMIC_CX_DATA_MSB               = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?)"
   textline ""
   bitfld.long 0x0   0.--1.       "[1 : 0]    RBIF_PMIC_CX_ADDR                   = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00070040$ PER_TESLA9X45_Part5.per -queue MX_RBIF_PMIC_ADDR"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00070044
tree " MX_RBCPR_TIMER_INTERVAL [RW]                                      0x00070044"
  group.long 0x0--0x3
   textline "POR 0x0000FFFF    MASK = 0xFFFFFFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print MX_RBCPR_TIMER_INTERVAL PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.long 0 0.--31. 1  "[31 : 0]   INTERVAL                            = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00070044$ PER_TESLA9X45_Part5.per -queue MX_RBCPR_TIMER_INTERVAL"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00070048
tree " MX_RBIF_LIMIT [RW]                                                0x00070048"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x00000FFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print MX_RBIF_LIMIT PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   6.--11.      "[11 : 6]   CEILING                             = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?),0x08 (?),0x09 (?),0x0A (?),0x0B (?),0x0C (?),0x0D (?),0x0E (?),0x0F (?),0x10 (?),0x11 (?),0x12 (?),0x13 (?),0x14 (?),0x15 (?),0x16 (?),0x17 (?),0x18 (?),0x19 (?),0x1A (?),0x1B (?),0x1C (?),0x1D (?),0x1E (?),0x1F (?),0x20 (?),0x21 (?),0x22 (?),0x23 (?),0x24 (?),0x25 (?),0x26 (?),0x27 (?),0x28 (?),0x29 (?),0x2A (?),0x2B (?),0x2C (?),0x2D (?),0x2E (?),0x2F (?),0x30 (?),0x31 (?),0x32 (?),0x33 (?),0x34 (?),0x35 (?),0x36 (?),0x37 (?),0x38 (?),0x39 (?),0x3A (?),0x3B (?),0x3C (?),0x3D (?),0x3E (?),0x3F (?)"
   textline ""
   bitfld.long 0x0   0.--5.       "[5 : 0]    FLOOR                               = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?),0x08 (?),0x09 (?),0x0A (?),0x0B (?),0x0C (?),0x0D (?),0x0E (?),0x0F (?),0x10 (?),0x11 (?),0x12 (?),0x13 (?),0x14 (?),0x15 (?),0x16 (?),0x17 (?),0x18 (?),0x19 (?),0x1A (?),0x1B (?),0x1C (?),0x1D (?),0x1E (?),0x1F (?),0x20 (?),0x21 (?),0x22 (?),0x23 (?),0x24 (?),0x25 (?),0x26 (?),0x27 (?),0x28 (?),0x29 (?),0x2A (?),0x2B (?),0x2C (?),0x2D (?),0x2E (?),0x2F (?),0x30 (?),0x31 (?),0x32 (?),0x33 (?),0x34 (?),0x35 (?),0x36 (?),0x37 (?),0x38 (?),0x39 (?),0x3A (?),0x3B (?),0x3C (?),0x3D (?),0x3E (?),0x3F (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00070048$ PER_TESLA9X45_Part5.per -queue MX_RBIF_LIMIT"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0007004C
tree " MX_RBIF_TIMER_ADJUST [RW]                                         0x0007004C"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x0001FFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print MX_RBIF_TIMER_ADJUST PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   16.          "[ 16 ]     AUTO_LOOP_DISABLE                   = " "0x00 (?),0x01 (?)"
   textline ""
   hexmask.long.byte 0 8.--15. 1  "[15 : 8]   CLAMP_TIMER_INTERVAL                = "
   textline ""
   bitfld.long 0x0   4.--7.       "[7 : 4]    CONSECUTIVE_DN                      = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?),0x08 (?),0x09 (?),0x0A (?),0x0B (?),0x0C (?),0x0D (?),0x0E (?),0x0F (?)"
   textline ""
   bitfld.long 0x0   0.--3.       "[3 : 0]    CONSECUTIVE_UP                      = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?),0x08 (?),0x09 (?),0x0A (?),0x0B (?),0x0C (?),0x0D (?),0x0E (?),0x0F (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0007004C$ PER_TESLA9X45_Part5.per -queue MX_RBIF_TIMER_ADJUST"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00070060
tree " MX_RBCPR_GCNT_TARGET0 [RW]                                        0x00070060"
  group.long 0x0--0x3
   textline "POR 0x000203E8    MASK = 0x003FFFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print MX_RBCPR_GCNT_TARGET0 PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.word 0 12.--21. 1 "[21 : 12]  GCNT0                               = "
   textline ""
   hexmask.long.word 0 0.--11. 1  "[11 : 0]   TARGET0                             = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00070060$ PER_TESLA9X45_Part5.per -queue MX_RBCPR_GCNT_TARGET0"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00070064
tree " MX_RBCPR_GCNT_TARGET1 [RW]                                        0x00070064"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x003FFFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print MX_RBCPR_GCNT_TARGET1 PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.word 0 12.--21. 1 "[21 : 12]  GCNT1                               = "
   textline ""
   hexmask.long.word 0 0.--11. 1  "[11 : 0]   TARGET1                             = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00070064$ PER_TESLA9X45_Part5.per -queue MX_RBCPR_GCNT_TARGET1"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00070068
tree " MX_RBCPR_GCNT_TARGET2 [RW]                                        0x00070068"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x003FFFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print MX_RBCPR_GCNT_TARGET2 PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.word 0 12.--21. 1 "[21 : 12]  GCNT2                               = "
   textline ""
   hexmask.long.word 0 0.--11. 1  "[11 : 0]   TARGET2                             = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00070068$ PER_TESLA9X45_Part5.per -queue MX_RBCPR_GCNT_TARGET2"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0007006C
tree " MX_RBCPR_GCNT_TARGET3 [RW]                                        0x0007006C"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x003FFFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print MX_RBCPR_GCNT_TARGET3 PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.word 0 12.--21. 1 "[21 : 12]  GCNT3                               = "
   textline ""
   hexmask.long.word 0 0.--11. 1  "[11 : 0]   TARGET3                             = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0007006C$ PER_TESLA9X45_Part5.per -queue MX_RBCPR_GCNT_TARGET3"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00070070
tree " MX_RBCPR_GCNT_TARGET4 [RW]                                        0x00070070"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x003FFFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print MX_RBCPR_GCNT_TARGET4 PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.word 0 12.--21. 1 "[21 : 12]  GCNT4                               = "
   textline ""
   hexmask.long.word 0 0.--11. 1  "[11 : 0]   TARGET4                             = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00070070$ PER_TESLA9X45_Part5.per -queue MX_RBCPR_GCNT_TARGET4"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00070074
tree " MX_RBCPR_GCNT_TARGET5 [RW]                                        0x00070074"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x003FFFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print MX_RBCPR_GCNT_TARGET5 PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.word 0 12.--21. 1 "[21 : 12]  GCNT5                               = "
   textline ""
   hexmask.long.word 0 0.--11. 1  "[11 : 0]   TARGET5                             = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00070074$ PER_TESLA9X45_Part5.per -queue MX_RBCPR_GCNT_TARGET5"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00070078
tree " MX_RBCPR_GCNT_TARGET6 [RW]                                        0x00070078"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x003FFFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print MX_RBCPR_GCNT_TARGET6 PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.word 0 12.--21. 1 "[21 : 12]  GCNT6                               = "
   textline ""
   hexmask.long.word 0 0.--11. 1  "[11 : 0]   TARGET6                             = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00070078$ PER_TESLA9X45_Part5.per -queue MX_RBCPR_GCNT_TARGET6"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0007007C
tree " MX_RBCPR_GCNT_TARGET7 [RW]                                        0x0007007C"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x003FFFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print MX_RBCPR_GCNT_TARGET7 PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.word 0 12.--21. 1 "[21 : 12]  GCNT7                               = "
   textline ""
   hexmask.long.word 0 0.--11. 1  "[11 : 0]   TARGET7                             = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0007007C$ PER_TESLA9X45_Part5.per -queue MX_RBCPR_GCNT_TARGET7"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00070080
tree " MX_RBCPR_STEP_QUOT [RW]                                           0x00070080"
  group.long 0x0--0x3
   textline "POR 0x00000032    MASK = 0x00000FFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print MX_RBCPR_STEP_QUOT PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   8.--11.      "[11 : 8]   IDLE_CLOCKS                         = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?),0x08 (?),0x09 (?),0x0A (?),0x0B (?),0x0C (?),0x0D (?),0x0E (?),0x0F (?)"
   textline ""
   hexmask.long.byte 0 0.--7. 1   "[7 : 0]    STEP_QUOT                           = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00070080$ PER_TESLA9X45_Part5.per -queue MX_RBCPR_STEP_QUOT"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00070090
tree " MX_RBCPR_CTL [RW]                                                 0x00070090"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0xFF7DFFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print MX_RBCPR_CTL PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   28.--31.     "[31 : 28]  DN_THRESHOLD                        = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?),0x08 (?),0x09 (?),0x0A (?),0x0B (?),0x0C (?),0x0D (?),0x0E (?),0x0F (?)"
   textline ""
   bitfld.long 0x0   24.--27.     "[27 : 24]  UP_THRESHOLD                        = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?),0x08 (?),0x09 (?),0x0A (?),0x0B (?),0x0C (?),0x0D (?),0x0E (?),0x0F (?)"
   textline ""
   bitfld.long 0x0   18.--22.     "[22 : 18]  MIN_MX_CX_DELTA                     = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?),0x08 (?),0x09 (?),0x0A (?),0x0B (?),0x0C (?),0x0D (?),0x0E (?),0x0F (?),0x10 (?),0x11 (?),0x12 (?),0x13 (?),0x14 (?),0x15 (?),0x16 (?),0x17 (?),0x18 (?),0x19 (?),0x1A (?),0x1B (?),0x1C (?),0x1D (?),0x1E (?),0x1F (?)"
   textline ""
   bitfld.long 0x0   12.--16.     "[16 : 12]  MAX_MX_CX_DELTA                     = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?),0x08 (?),0x09 (?),0x0A (?),0x0B (?),0x0C (?),0x0D (?),0x0E (?),0x0F (?),0x10 (?),0x11 (?),0x12 (?),0x13 (?),0x14 (?),0x15 (?),0x16 (?),0x17 (?),0x18 (?),0x19 (?),0x1A (?),0x1B (?),0x1C (?),0x1D (?),0x1E (?),0x1F (?)"
   textline ""
   bitfld.long 0x0   11.          "[ 11 ]     HW_TO_PMIC_MX_EN                    = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   10.          "[ 10 ]     COUNT_MODE                          = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   7.--9.       "[9 : 7]    DEBUG_BUS_SEL                       = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?)"
   textline ""
   bitfld.long 0x0   6.           "[ 6 ]      SW_AUTO_CONT_NACK_DN_EN             = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   5.           "[ 5 ]      SW_AUTO_CONT_ACK_EN                 = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   4.           "[ 4 ]      HW_TO_PMIC_EN                       = " "0x00 (SW_MODE),0x01 (HW_MODE)"
   textline ""
   bitfld.long 0x0   3.           "[ 3 ]      TIMER_EN                            = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   2.           "[ 2 ]      INCR_MODE                           = " "0x00 (PROPORTIONAL_TO_QUOT),0x01 (INCREMENTAL)"
   textline ""
   bitfld.long 0x0   1.           "[ 1 ]      FORCE_TIMER                         = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   0.           "[ 0 ]      LOOP_EN                             = " "0x00 (?),0x01 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00070090$ PER_TESLA9X45_Part5.per -queue MX_RBCPR_CTL"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00070094
tree " MX_RBIF_SW_VLEVEL [RW]                                            0x00070094"
  group.long 0x0--0x3
   textline "POR 0x00000820    MASK = 0x00000FFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print MX_RBIF_SW_VLEVEL PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   6.--11.      "[11 : 6]   SW_MX_VLEVEL                        = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?),0x08 (?),0x09 (?),0x0A (?),0x0B (?),0x0C (?),0x0D (?),0x0E (?),0x0F (?),0x10 (?),0x11 (?),0x12 (?),0x13 (?),0x14 (?),0x15 (?),0x16 (?),0x17 (?),0x18 (?),0x19 (?),0x1A (?),0x1B (?),0x1C (?),0x1D (?),0x1E (?),0x1F (?),0x20 (?),0x21 (?),0x22 (?),0x23 (?),0x24 (?),0x25 (?),0x26 (?),0x27 (?),0x28 (?),0x29 (?),0x2A (?),0x2B (?),0x2C (?),0x2D (?),0x2E (?),0x2F (?),0x30 (?),0x31 (?),0x32 (?),0x33 (?),0x34 (?),0x35 (?),0x36 (?),0x37 (?),0x38 (?),0x39 (?),0x3A (?),0x3B (?),0x3C (?),0x3D (?),0x3E (?),0x3F (?)"
   textline ""
   bitfld.long 0x0   0.--5.       "[5 : 0]    SW_VLEVEL                           = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?),0x08 (?),0x09 (?),0x0A (?),0x0B (?),0x0C (?),0x0D (?),0x0E (?),0x0F (?),0x10 (?),0x11 (?),0x12 (?),0x13 (?),0x14 (?),0x15 (?),0x16 (?),0x17 (?),0x18 (?),0x19 (?),0x1A (?),0x1B (?),0x1C (?),0x1D (?),0x1E (?),0x1F (?),0x20 (?),0x21 (?),0x22 (?),0x23 (?),0x24 (?),0x25 (?),0x26 (?),0x27 (?),0x28 (?),0x29 (?),0x2A (?),0x2B (?),0x2C (?),0x2D (?),0x2E (?),0x2F (?),0x30 (?),0x31 (?),0x32 (?),0x33 (?),0x34 (?),0x35 (?),0x36 (?),0x37 (?),0x38 (?),0x39 (?),0x3A (?),0x3B (?),0x3C (?),0x3D (?),0x3E (?),0x3F (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00070094$ PER_TESLA9X45_Part5.per -queue MX_RBIF_SW_VLEVEL"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00070098
tree " MX_RBIF_CONT_ACK_CMD [C]                                          0x00070098"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0xFFFFFFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print MX_RBIF_CONT_ACK_CMD PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.long 0 0.--31. 1  "[31 : 0]   RBIF_CONT_ACK_CMD                   = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00070098$ PER_TESLA9X45_Part5.per -queue MX_RBIF_CONT_ACK_CMD"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0007009C
tree " MX_RBIF_CONT_NACK_CMD [C]                                         0x0007009C"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0xFFFFFFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print MX_RBIF_CONT_NACK_CMD PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.long 0 0.--31. 1  "[31 : 0]   RBIF_CONT_NACK_CMD                  = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0007009C$ PER_TESLA9X45_Part5.per -queue MX_RBIF_CONT_NACK_CMD"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x000700A0
tree " MX_RBCPR_RESULT_0 [R]                                             0x000700A0"
  group.long 0x0--0x3
   textline "POR 0x00080000    MASK = 0x000FFFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print MX_RBCPR_RESULT_0 PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   19.          "[ 19 ]     BUSY                                = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   18.          "[ 18 ]     ERROR_LT_0                          = " "0x00 (?),0x01 (?)"
   textline ""
   hexmask.long.word 0 6.--17. 1  "[17 : 6]   ERROR                               = "
   textline ""
   bitfld.long 0x0   2.--5.       "[5 : 2]    ERROR_STEPS                         = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?),0x08 (?),0x09 (?),0x0A (?),0x0B (?),0x0C (?),0x0D (?),0x0E (?),0x0F (?)"
   textline ""
   bitfld.long 0x0   1.           "[ 1 ]      STEP_UP                             = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   0.           "[ 0 ]      STEP_DN                             = " "0x00 (?),0x01 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x000700A0$ PER_TESLA9X45_Part5.per -queue MX_RBCPR_RESULT_0"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x000700A4
tree " MX_RBCPR_RESULT_1 [R]                                             0x000700A4"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x000FFFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print MX_RBCPR_RESULT_1 PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   13.--19.     "[19 : 13]  SENSOR_SLOW                         = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?),0x08 (?),0x09 (?),0x0A (?),0x0B (?),0x0C (?),0x0D (?),0x0E (?),0x0F (?),0x10 (?),0x11 (?),0x12 (?),0x13 (?),0x14 (?),0x15 (?),0x16 (?),0x17 (?),0x18 (?),0x19 (?),0x1A (?),0x1B (?),0x1C (?),0x1D (?),0x1E (?),0x1F (?),0x20 (?),0x21 (?),0x22 (?),0x23 (?),0x24 (?),0x25 (?),0x26 (?),0x27 (?),0x28 (?),0x29 (?),0x2A (?),0x2B (?),0x2C (?),0x2D (?),0x2E (?),0x2F (?),0x30 (?),0x31 (?),0x32 (?),0x33 (?),0x34 (?),0x35 (?),0x36 (?),0x37 (?),0x38 (?),0x39 (?),0x3A (?),0x3B (?),0x3C (?),0x3D (?),0x3E (?),0x3F (?),0x40 (?),0x41 (?),0x42 (?),0x43 (?),0x44 (?),0x45 (?),0x46 (?),0x47 (?),0x48 (?),0x49 (?),0x4A (?),0x4B (?),0x4C (?),0x4D (?),0x4E (?),0x4F (?),0x50 (?),0x51 (?),0x52 (?),0x53 (?),0x54 (?),0x55 (?),0x56 (?),0x57 (?),0x58 (?),0x59 (?),0x5A (?),0x5B (?),0x5C (?),0x5D (?),0x5E (?),0x5F (?),0x60 (?),0x61 (?),0x62 (?),0x63 (?),0x64 (?),0x65 (?),0x66 (?),0x67 (?),0x68 (?),0x69 (?),0x6A (?),0x6B (?),0x6C (?),0x6D (?),0x6E (?),0x6F (?),0x70 (?),0x71 (?),0x72 (?),0x73 (?),0x74 (?),0x75 (?),0x76 (?),0x77 (?),0x78 (?),0x79 (?),0x7A (?),0x7B (?),0x7C (?),0x7D (?),0x7E (?),0x7F (?)"
   textline ""
   bitfld.long 0x0   10.--12.     "[12 : 10]  SEL_SLOW                            = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?)"
   textline ""
   bitfld.long 0x0   3.--9.       "[9 : 3]    SENSOR_FAST                         = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?),0x08 (?),0x09 (?),0x0A (?),0x0B (?),0x0C (?),0x0D (?),0x0E (?),0x0F (?),0x10 (?),0x11 (?),0x12 (?),0x13 (?),0x14 (?),0x15 (?),0x16 (?),0x17 (?),0x18 (?),0x19 (?),0x1A (?),0x1B (?),0x1C (?),0x1D (?),0x1E (?),0x1F (?),0x20 (?),0x21 (?),0x22 (?),0x23 (?),0x24 (?),0x25 (?),0x26 (?),0x27 (?),0x28 (?),0x29 (?),0x2A (?),0x2B (?),0x2C (?),0x2D (?),0x2E (?),0x2F (?),0x30 (?),0x31 (?),0x32 (?),0x33 (?),0x34 (?),0x35 (?),0x36 (?),0x37 (?),0x38 (?),0x39 (?),0x3A (?),0x3B (?),0x3C (?),0x3D (?),0x3E (?),0x3F (?),0x40 (?),0x41 (?),0x42 (?),0x43 (?),0x44 (?),0x45 (?),0x46 (?),0x47 (?),0x48 (?),0x49 (?),0x4A (?),0x4B (?),0x4C (?),0x4D (?),0x4E (?),0x4F (?),0x50 (?),0x51 (?),0x52 (?),0x53 (?),0x54 (?),0x55 (?),0x56 (?),0x57 (?),0x58 (?),0x59 (?),0x5A (?),0x5B (?),0x5C (?),0x5D (?),0x5E (?),0x5F (?),0x60 (?),0x61 (?),0x62 (?),0x63 (?),0x64 (?),0x65 (?),0x66 (?),0x67 (?),0x68 (?),0x69 (?),0x6A (?),0x6B (?),0x6C (?),0x6D (?),0x6E (?),0x6F (?),0x70 (?),0x71 (?),0x72 (?),0x73 (?),0x74 (?),0x75 (?),0x76 (?),0x77 (?),0x78 (?),0x79 (?),0x7A (?),0x7B (?),0x7C (?),0x7D (?),0x7E (?),0x7F (?)"
   textline ""
   bitfld.long 0x0   0.--2.       "[2 : 0]    SEL_FAST                            = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x000700A4$ PER_TESLA9X45_Part5.per -queue MX_RBCPR_RESULT_1"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00070100
tree " MX_RBIF_IRQ_EN_0 [RW]                                             0x00070100"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x0000007F    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print MX_RBIF_IRQ_EN_0 PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   6.           "[ 6 ]      CLAMP_CHANGE_WHILE_BUSY_EN          = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   5.           "[ 5 ]      MAX_FLAG_EN                         = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   4.           "[ 4 ]      UP_FLAG_EN                          = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   3.           "[ 3 ]      MID_FLAG_EN                         = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   2.           "[ 2 ]      DOWN_FLAG_EN                        = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   1.           "[ 1 ]      MIN_FLAG_EN                         = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   0.           "[ 0 ]      RBCPR_DONE_EN                       = " "0x00 (?),0x01 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00070100$ PER_TESLA9X45_Part5.per -queue MX_RBIF_IRQ_EN_0"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00070104
tree " MX_RBIF_IRQ_EN_1 [RW]                                             0x00070104"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x0000007F    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print MX_RBIF_IRQ_EN_1 PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   6.           "[ 6 ]      CLAMP_CHANGE_WHILE_BUSY_EN          = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   5.           "[ 5 ]      MAX_FLAG_EN                         = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   4.           "[ 4 ]      UP_FLAG_EN                          = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   3.           "[ 3 ]      MID_FLAG_EN                         = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   2.           "[ 2 ]      DOWN_FLAG_EN                        = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   1.           "[ 1 ]      MIN_FLAG_EN                         = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   0.           "[ 0 ]      RBCPR_DONE_EN                       = " "0x00 (?),0x01 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00070104$ PER_TESLA9X45_Part5.per -queue MX_RBIF_IRQ_EN_1"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00070108
tree " MX_RBIF_IRQ_EN_2 [RW]                                             0x00070108"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x0000007F    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print MX_RBIF_IRQ_EN_2 PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   6.           "[ 6 ]      CLAMP_CHANGE_WHILE_BUSY_EN          = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   5.           "[ 5 ]      MAX_FLAG_EN                         = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   4.           "[ 4 ]      UP_FLAG_EN                          = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   3.           "[ 3 ]      MID_FLAG_EN                         = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   2.           "[ 2 ]      DOWN_FLAG_EN                        = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   1.           "[ 1 ]      MIN_FLAG_EN                         = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   0.           "[ 0 ]      RBCPR_DONE_EN                       = " "0x00 (?),0x01 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00070108$ PER_TESLA9X45_Part5.per -queue MX_RBIF_IRQ_EN_2"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00070110
tree " MX_RBIF_IRQ_CLEAR [C]                                             0x00070110"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x0000007F    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print MX_RBIF_IRQ_CLEAR PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   6.           "[ 6 ]      CLAMP_CHANGE_WHILE_BUSY_CLEAR       = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   5.           "[ 5 ]      MAX_FLAG_CLEAR                      = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   4.           "[ 4 ]      UP_FLAG_CLEAR                       = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   3.           "[ 3 ]      MID_FLAG_CLEAR                      = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   2.           "[ 2 ]      DOWN_FLAG_CLEAR                     = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   1.           "[ 1 ]      MIN_FLAG_CLEAR                      = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   0.           "[ 0 ]      RBCPR_DONE_CLEAR                    = " "0x00 (?),0x01 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00070110$ PER_TESLA9X45_Part5.per -queue MX_RBIF_IRQ_CLEAR"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00070114
tree " MX_RBIF_IRQ_STATUS [R]                                            0x00070114"
  group.long 0x0--0x3
   textline "POR 0x00000040    MASK = 0x0000007F    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print MX_RBIF_IRQ_STATUS PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   6.           "[ 6 ]      CLAMP_CHANGE_WHILE_BUSY             = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   5.           "[ 5 ]      MAX_FLAG                            = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   4.           "[ 4 ]      UP_FLAG                             = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   3.           "[ 3 ]      MID_FLAG                            = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   2.           "[ 2 ]      DOWN_FLAG                           = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   1.           "[ 1 ]      MIN_FLAG                            = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   0.           "[ 0 ]      RBCPR_DONE                          = " "0x00 (?),0x01 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00070114$ PER_TESLA9X45_Part5.per -queue MX_RBIF_IRQ_STATUS"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00070118
tree " MX_RBCPR_QUOT_AVG [R]                                             0x00070118"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x3FFFFFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print MX_RBCPR_QUOT_AVG PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.long 0 8.--29. 1  "[29 : 8]   QUOT_SUM                            = "
   textline ""
   hexmask.long.byte 0 0.--7. 1   "[7 : 0]    SENSOR_SUM                          = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00070118$ PER_TESLA9X45_Part5.per -queue MX_RBCPR_QUOT_AVG"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0007011C
tree " MX_RBCPR_DEBUG0 [R]                                               0x0007011C"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0xFFFFFFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print MX_RBCPR_DEBUG0 PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.word 0 21.--31. 1 "[31 : 21]  SCLK_CNT1                           = "
   textline ""
   hexmask.long.word 0 10.--20. 1 "[20 : 10]  SCLK_CNT0                           = "
   textline ""
   bitfld.long 0x0   8.--9.       "[9 : 8]    SCLK_CNT_FAIL                       = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?)"
   textline ""
   bitfld.long 0x0   6.--7.       "[7 : 6]    DBG_END_OF_CHAIN_DREG               = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?)"
   textline ""
   bitfld.long 0x0   0.--5.       "[5 : 0]    DBG_SHIFT_RING                      = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?),0x08 (?),0x09 (?),0x0A (?),0x0B (?),0x0C (?),0x0D (?),0x0E (?),0x0F (?),0x10 (?),0x11 (?),0x12 (?),0x13 (?),0x14 (?),0x15 (?),0x16 (?),0x17 (?),0x18 (?),0x19 (?),0x1A (?),0x1B (?),0x1C (?),0x1D (?),0x1E (?),0x1F (?),0x20 (?),0x21 (?),0x22 (?),0x23 (?),0x24 (?),0x25 (?),0x26 (?),0x27 (?),0x28 (?),0x29 (?),0x2A (?),0x2B (?),0x2C (?),0x2D (?),0x2E (?),0x2F (?),0x30 (?),0x31 (?),0x32 (?),0x33 (?),0x34 (?),0x35 (?),0x36 (?),0x37 (?),0x38 (?),0x39 (?),0x3A (?),0x3B (?),0x3C (?),0x3D (?),0x3E (?),0x3F (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0007011C$ PER_TESLA9X45_Part5.per -queue MX_RBCPR_DEBUG0"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00070120
tree " MX_RBCPR_DEBUG1 [R]                                               0x00070120"
  group.long 0x0--0x3
   textline "POR 0xA0FFF000    MASK = 0xFFFFFFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print MX_RBCPR_DEBUG1 PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   31.          "[ 31 ]     DBG_END_OF_CHAIN_ENA                = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   30.          "[ 30 ]     DBG_VALID                           = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   29.          "[ 29 ]     DBG_END_OF_CHAIN_MODE               = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   27.--28.     "[28 : 27]  DBG_END_OF_CHAIN_DATA               = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?)"
   textline ""
   bitfld.long 0x0   24.--26.     "[26 : 24]  DBG_FSM_STATE                       = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?)"
   textline ""
   hexmask.long.word 0 12.--23. 1 "[23 : 12]  QUOT_SLOW                           = "
   textline ""
   hexmask.long.word 0 0.--11. 1  "[11 : 0]   QUOT_FAST                           = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00070120$ PER_TESLA9X45_Part5.per -queue MX_RBCPR_DEBUG1"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00070124
tree " MX_RBCPR_DEBUG2 [R]                                               0x00070124"
  group.long 0x0--0x3
   textline "POR 0x00000032    MASK = 0xFFFFFFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print MX_RBCPR_DEBUG2 PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   31.          "[ 31 ]     DBG_SEL_DONE                        = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   30.          "[ 30 ]     DBG_SENSOR_DONE                     = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   23.--29.     "[29 : 23]  DBG_SENSOR                          = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?),0x08 (?),0x09 (?),0x0A (?),0x0B (?),0x0C (?),0x0D (?),0x0E (?),0x0F (?),0x10 (?),0x11 (?),0x12 (?),0x13 (?),0x14 (?),0x15 (?),0x16 (?),0x17 (?),0x18 (?),0x19 (?),0x1A (?),0x1B (?),0x1C (?),0x1D (?),0x1E (?),0x1F (?),0x20 (?),0x21 (?),0x22 (?),0x23 (?),0x24 (?),0x25 (?),0x26 (?),0x27 (?),0x28 (?),0x29 (?),0x2A (?),0x2B (?),0x2C (?),0x2D (?),0x2E (?),0x2F (?),0x30 (?),0x31 (?),0x32 (?),0x33 (?),0x34 (?),0x35 (?),0x36 (?),0x37 (?),0x38 (?),0x39 (?),0x3A (?),0x3B (?),0x3C (?),0x3D (?),0x3E (?),0x3F (?),0x40 (?),0x41 (?),0x42 (?),0x43 (?),0x44 (?),0x45 (?),0x46 (?),0x47 (?),0x48 (?),0x49 (?),0x4A (?),0x4B (?),0x4C (?),0x4D (?),0x4E (?),0x4F (?),0x50 (?),0x51 (?),0x52 (?),0x53 (?),0x54 (?),0x55 (?),0x56 (?),0x57 (?),0x58 (?),0x59 (?),0x5A (?),0x5B (?),0x5C (?),0x5D (?),0x5E (?),0x5F (?),0x60 (?),0x61 (?),0x62 (?),0x63 (?),0x64 (?),0x65 (?),0x66 (?),0x67 (?),0x68 (?),0x69 (?),0x6A (?),0x6B (?),0x6C (?),0x6D (?),0x6E (?),0x6F (?),0x70 (?),0x71 (?),0x72 (?),0x73 (?),0x74 (?),0x75 (?),0x76 (?),0x77 (?),0x78 (?),0x79 (?),0x7A (?),0x7B (?),0x7C (?),0x7D (?),0x7E (?),0x7F (?)"
   textline ""
   bitfld.long 0x0   20.--22.     "[22 : 20]  DBG_SEL                             = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?)"
   textline ""
   hexmask.long.word 0 8.--19. 1  "[19 : 8]   DBG_QUOT                            = "
   textline ""
   hexmask.long.byte 0 0.--7. 1   "[7 : 0]    DBG_STEP_QUOT                       = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00070124$ PER_TESLA9X45_Part5.per -queue MX_RBCPR_DEBUG2"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00070128
tree " MX_RBCPR_BIST_MINMAX [RW]                                         0x00070128"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x00FFFFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print MX_RBCPR_BIST_MINMAX PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.word 0 12.--23. 1 "[23 : 12]  BIST_QUOT_ABSMIN                    = "
   textline ""
   hexmask.long.word 0 0.--11. 1  "[11 : 0]   BIST_QUOT_ABSMAX                    = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00070128$ PER_TESLA9X45_Part5.per -queue MX_RBCPR_BIST_MINMAX"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0007012C
tree " MX_RBCPR_BIST_RESULT [R]                                          0x0007012C"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x0001FFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print MX_RBCPR_BIST_RESULT PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   16.          "[ 16 ]     SENSOR_ELAB_DONE                    = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   15.          "[ 15 ]     BIST_FAIL                           = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   12.--14.     "[14 : 12]  BIST_FAIL_LASTSEL                   = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?)"
   textline ""
   hexmask.long.word 0 0.--11. 1  "[11 : 0]   BIST_FAIL_LASTQUOT                  = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0007012C$ PER_TESLA9X45_Part5.per -queue MX_RBCPR_BIST_RESULT"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00070130
tree " MX_RBCPR_BIST_FAIL_MAP0 [R]                                       0x00070130"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0xFFFFFFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print MX_RBCPR_BIST_FAIL_MAP0 PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.long 0 0.--31. 1  "[31 : 0]   BIST_FAIL_MAP                       = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00070130$ PER_TESLA9X45_Part5.per -queue MX_RBCPR_BIST_FAIL_MAP0"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00070134
tree " MX_RBCPR_BIST_FAIL_MAP1 [R]                                       0x00070134"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0xFFFFFFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print MX_RBCPR_BIST_FAIL_MAP1 PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.long 0 0.--31. 1  "[31 : 0]   BIST_FAIL_MAP                       = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00070134$ PER_TESLA9X45_Part5.per -queue MX_RBCPR_BIST_FAIL_MAP1"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00070138
tree " MX_RBCPR_BIST_FAIL_MAP2 [R]                                       0x00070138"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0xFFFFFFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print MX_RBCPR_BIST_FAIL_MAP2 PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.long 0 0.--31. 1  "[31 : 0]   BIST_FAIL_MAP                       = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00070138$ PER_TESLA9X45_Part5.per -queue MX_RBCPR_BIST_FAIL_MAP2"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0007013C
tree " MX_RBCPR_BIST_FAIL_MAP3 [R]                                       0x0007013C"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0xFFFFFFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print MX_RBCPR_BIST_FAIL_MAP3 PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.long 0 0.--31. 1  "[31 : 0]   BIST_FAIL_MAP                       = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0007013C$ PER_TESLA9X45_Part5.per -queue MX_RBCPR_BIST_FAIL_MAP3"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00070140
tree " MX_RBCPR_LOG_0 [R]                                                0x00070140"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0xFFFFF7FF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print MX_RBCPR_LOG_0 PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.word 0 18.--31. 1 "[31 : 18]  MID_COUNT                           = "
   textline ""
   bitfld.long 0x0   12.--17.     "[17 : 12]  MX_VLEVEL                           = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?),0x08 (?),0x09 (?),0x0A (?),0x0B (?),0x0C (?),0x0D (?),0x0E (?),0x0F (?),0x10 (?),0x11 (?),0x12 (?),0x13 (?),0x14 (?),0x15 (?),0x16 (?),0x17 (?),0x18 (?),0x19 (?),0x1A (?),0x1B (?),0x1C (?),0x1D (?),0x1E (?),0x1F (?),0x20 (?),0x21 (?),0x22 (?),0x23 (?),0x24 (?),0x25 (?),0x26 (?),0x27 (?),0x28 (?),0x29 (?),0x2A (?),0x2B (?),0x2C (?),0x2D (?),0x2E (?),0x2F (?),0x30 (?),0x31 (?),0x32 (?),0x33 (?),0x34 (?),0x35 (?),0x36 (?),0x37 (?),0x38 (?),0x39 (?),0x3A (?),0x3B (?),0x3C (?),0x3D (?),0x3E (?),0x3F (?)"
   textline ""
   bitfld.long 0x0   10.          "[ 10 ]     MAX_FLAG                            = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   9.           "[ 9 ]      UP_FLAG                             = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   8.           "[ 8 ]      MID_FLAG                            = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   7.           "[ 7 ]      DOWN_FLAG                           = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   6.           "[ 6 ]      MIN_FLAG                            = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   0.--5.       "[5 : 0]    VLEVEL                              = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?),0x08 (?),0x09 (?),0x0A (?),0x0B (?),0x0C (?),0x0D (?),0x0E (?),0x0F (?),0x10 (?),0x11 (?),0x12 (?),0x13 (?),0x14 (?),0x15 (?),0x16 (?),0x17 (?),0x18 (?),0x19 (?),0x1A (?),0x1B (?),0x1C (?),0x1D (?),0x1E (?),0x1F (?),0x20 (?),0x21 (?),0x22 (?),0x23 (?),0x24 (?),0x25 (?),0x26 (?),0x27 (?),0x28 (?),0x29 (?),0x2A (?),0x2B (?),0x2C (?),0x2D (?),0x2E (?),0x2F (?),0x30 (?),0x31 (?),0x32 (?),0x33 (?),0x34 (?),0x35 (?),0x36 (?),0x37 (?),0x38 (?),0x39 (?),0x3A (?),0x3B (?),0x3C (?),0x3D (?),0x3E (?),0x3F (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00070140$ PER_TESLA9X45_Part5.per -queue MX_RBCPR_LOG_0"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00070144
tree " MX_RBCPR_LOG_1 [R]                                                0x00070144"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0xFFFFF7FF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print MX_RBCPR_LOG_1 PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.word 0 18.--31. 1 "[31 : 18]  MID_COUNT                           = "
   textline ""
   bitfld.long 0x0   12.--17.     "[17 : 12]  MX_VLEVEL                           = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?),0x08 (?),0x09 (?),0x0A (?),0x0B (?),0x0C (?),0x0D (?),0x0E (?),0x0F (?),0x10 (?),0x11 (?),0x12 (?),0x13 (?),0x14 (?),0x15 (?),0x16 (?),0x17 (?),0x18 (?),0x19 (?),0x1A (?),0x1B (?),0x1C (?),0x1D (?),0x1E (?),0x1F (?),0x20 (?),0x21 (?),0x22 (?),0x23 (?),0x24 (?),0x25 (?),0x26 (?),0x27 (?),0x28 (?),0x29 (?),0x2A (?),0x2B (?),0x2C (?),0x2D (?),0x2E (?),0x2F (?),0x30 (?),0x31 (?),0x32 (?),0x33 (?),0x34 (?),0x35 (?),0x36 (?),0x37 (?),0x38 (?),0x39 (?),0x3A (?),0x3B (?),0x3C (?),0x3D (?),0x3E (?),0x3F (?)"
   textline ""
   bitfld.long 0x0   10.          "[ 10 ]     MAX_FLAG                            = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   9.           "[ 9 ]      UP_FLAG                             = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   8.           "[ 8 ]      MID_FLAG                            = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   7.           "[ 7 ]      DOWN_FLAG                           = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   6.           "[ 6 ]      MIN_FLAG                            = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   0.--5.       "[5 : 0]    VLEVEL                              = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?),0x08 (?),0x09 (?),0x0A (?),0x0B (?),0x0C (?),0x0D (?),0x0E (?),0x0F (?),0x10 (?),0x11 (?),0x12 (?),0x13 (?),0x14 (?),0x15 (?),0x16 (?),0x17 (?),0x18 (?),0x19 (?),0x1A (?),0x1B (?),0x1C (?),0x1D (?),0x1E (?),0x1F (?),0x20 (?),0x21 (?),0x22 (?),0x23 (?),0x24 (?),0x25 (?),0x26 (?),0x27 (?),0x28 (?),0x29 (?),0x2A (?),0x2B (?),0x2C (?),0x2D (?),0x2E (?),0x2F (?),0x30 (?),0x31 (?),0x32 (?),0x33 (?),0x34 (?),0x35 (?),0x36 (?),0x37 (?),0x38 (?),0x39 (?),0x3A (?),0x3B (?),0x3C (?),0x3D (?),0x3E (?),0x3F (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00070144$ PER_TESLA9X45_Part5.per -queue MX_RBCPR_LOG_1"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00070148
tree " MX_RBCPR_LOG_2 [R]                                                0x00070148"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0xFFFFF7FF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print MX_RBCPR_LOG_2 PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.word 0 18.--31. 1 "[31 : 18]  MID_COUNT                           = "
   textline ""
   bitfld.long 0x0   12.--17.     "[17 : 12]  MX_VLEVEL                           = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?),0x08 (?),0x09 (?),0x0A (?),0x0B (?),0x0C (?),0x0D (?),0x0E (?),0x0F (?),0x10 (?),0x11 (?),0x12 (?),0x13 (?),0x14 (?),0x15 (?),0x16 (?),0x17 (?),0x18 (?),0x19 (?),0x1A (?),0x1B (?),0x1C (?),0x1D (?),0x1E (?),0x1F (?),0x20 (?),0x21 (?),0x22 (?),0x23 (?),0x24 (?),0x25 (?),0x26 (?),0x27 (?),0x28 (?),0x29 (?),0x2A (?),0x2B (?),0x2C (?),0x2D (?),0x2E (?),0x2F (?),0x30 (?),0x31 (?),0x32 (?),0x33 (?),0x34 (?),0x35 (?),0x36 (?),0x37 (?),0x38 (?),0x39 (?),0x3A (?),0x3B (?),0x3C (?),0x3D (?),0x3E (?),0x3F (?)"
   textline ""
   bitfld.long 0x0   10.          "[ 10 ]     MAX_FLAG                            = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   9.           "[ 9 ]      UP_FLAG                             = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   8.           "[ 8 ]      MID_FLAG                            = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   7.           "[ 7 ]      DOWN_FLAG                           = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   6.           "[ 6 ]      MIN_FLAG                            = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   0.--5.       "[5 : 0]    VLEVEL                              = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?),0x08 (?),0x09 (?),0x0A (?),0x0B (?),0x0C (?),0x0D (?),0x0E (?),0x0F (?),0x10 (?),0x11 (?),0x12 (?),0x13 (?),0x14 (?),0x15 (?),0x16 (?),0x17 (?),0x18 (?),0x19 (?),0x1A (?),0x1B (?),0x1C (?),0x1D (?),0x1E (?),0x1F (?),0x20 (?),0x21 (?),0x22 (?),0x23 (?),0x24 (?),0x25 (?),0x26 (?),0x27 (?),0x28 (?),0x29 (?),0x2A (?),0x2B (?),0x2C (?),0x2D (?),0x2E (?),0x2F (?),0x30 (?),0x31 (?),0x32 (?),0x33 (?),0x34 (?),0x35 (?),0x36 (?),0x37 (?),0x38 (?),0x39 (?),0x3A (?),0x3B (?),0x3C (?),0x3D (?),0x3E (?),0x3F (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00070148$ PER_TESLA9X45_Part5.per -queue MX_RBCPR_LOG_2"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0007014C
tree " MX_RBCPR_LOG_3 [R]                                                0x0007014C"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0xFFFFF7FF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print MX_RBCPR_LOG_3 PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.word 0 18.--31. 1 "[31 : 18]  MID_COUNT                           = "
   textline ""
   bitfld.long 0x0   12.--17.     "[17 : 12]  MX_VLEVEL                           = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?),0x08 (?),0x09 (?),0x0A (?),0x0B (?),0x0C (?),0x0D (?),0x0E (?),0x0F (?),0x10 (?),0x11 (?),0x12 (?),0x13 (?),0x14 (?),0x15 (?),0x16 (?),0x17 (?),0x18 (?),0x19 (?),0x1A (?),0x1B (?),0x1C (?),0x1D (?),0x1E (?),0x1F (?),0x20 (?),0x21 (?),0x22 (?),0x23 (?),0x24 (?),0x25 (?),0x26 (?),0x27 (?),0x28 (?),0x29 (?),0x2A (?),0x2B (?),0x2C (?),0x2D (?),0x2E (?),0x2F (?),0x30 (?),0x31 (?),0x32 (?),0x33 (?),0x34 (?),0x35 (?),0x36 (?),0x37 (?),0x38 (?),0x39 (?),0x3A (?),0x3B (?),0x3C (?),0x3D (?),0x3E (?),0x3F (?)"
   textline ""
   bitfld.long 0x0   10.          "[ 10 ]     MAX_FLAG                            = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   9.           "[ 9 ]      UP_FLAG                             = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   8.           "[ 8 ]      MID_FLAG                            = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   7.           "[ 7 ]      DOWN_FLAG                           = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   6.           "[ 6 ]      MIN_FLAG                            = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   0.--5.       "[5 : 0]    VLEVEL                              = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?),0x08 (?),0x09 (?),0x0A (?),0x0B (?),0x0C (?),0x0D (?),0x0E (?),0x0F (?),0x10 (?),0x11 (?),0x12 (?),0x13 (?),0x14 (?),0x15 (?),0x16 (?),0x17 (?),0x18 (?),0x19 (?),0x1A (?),0x1B (?),0x1C (?),0x1D (?),0x1E (?),0x1F (?),0x20 (?),0x21 (?),0x22 (?),0x23 (?),0x24 (?),0x25 (?),0x26 (?),0x27 (?),0x28 (?),0x29 (?),0x2A (?),0x2B (?),0x2C (?),0x2D (?),0x2E (?),0x2F (?),0x30 (?),0x31 (?),0x32 (?),0x33 (?),0x34 (?),0x35 (?),0x36 (?),0x37 (?),0x38 (?),0x39 (?),0x3A (?),0x3B (?),0x3C (?),0x3D (?),0x3E (?),0x3F (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0007014C$ PER_TESLA9X45_Part5.per -queue MX_RBCPR_LOG_3"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00070150
tree " MX_RBCPR_LOG_4 [R]                                                0x00070150"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0xFFFFF7FF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print MX_RBCPR_LOG_4 PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.word 0 18.--31. 1 "[31 : 18]  MID_COUNT                           = "
   textline ""
   bitfld.long 0x0   12.--17.     "[17 : 12]  MX_VLEVEL                           = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?),0x08 (?),0x09 (?),0x0A (?),0x0B (?),0x0C (?),0x0D (?),0x0E (?),0x0F (?),0x10 (?),0x11 (?),0x12 (?),0x13 (?),0x14 (?),0x15 (?),0x16 (?),0x17 (?),0x18 (?),0x19 (?),0x1A (?),0x1B (?),0x1C (?),0x1D (?),0x1E (?),0x1F (?),0x20 (?),0x21 (?),0x22 (?),0x23 (?),0x24 (?),0x25 (?),0x26 (?),0x27 (?),0x28 (?),0x29 (?),0x2A (?),0x2B (?),0x2C (?),0x2D (?),0x2E (?),0x2F (?),0x30 (?),0x31 (?),0x32 (?),0x33 (?),0x34 (?),0x35 (?),0x36 (?),0x37 (?),0x38 (?),0x39 (?),0x3A (?),0x3B (?),0x3C (?),0x3D (?),0x3E (?),0x3F (?)"
   textline ""
   bitfld.long 0x0   10.          "[ 10 ]     MAX_FLAG                            = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   9.           "[ 9 ]      UP_FLAG                             = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   8.           "[ 8 ]      MID_FLAG                            = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   7.           "[ 7 ]      DOWN_FLAG                           = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   6.           "[ 6 ]      MIN_FLAG                            = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   0.--5.       "[5 : 0]    VLEVEL                              = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?),0x08 (?),0x09 (?),0x0A (?),0x0B (?),0x0C (?),0x0D (?),0x0E (?),0x0F (?),0x10 (?),0x11 (?),0x12 (?),0x13 (?),0x14 (?),0x15 (?),0x16 (?),0x17 (?),0x18 (?),0x19 (?),0x1A (?),0x1B (?),0x1C (?),0x1D (?),0x1E (?),0x1F (?),0x20 (?),0x21 (?),0x22 (?),0x23 (?),0x24 (?),0x25 (?),0x26 (?),0x27 (?),0x28 (?),0x29 (?),0x2A (?),0x2B (?),0x2C (?),0x2D (?),0x2E (?),0x2F (?),0x30 (?),0x31 (?),0x32 (?),0x33 (?),0x34 (?),0x35 (?),0x36 (?),0x37 (?),0x38 (?),0x39 (?),0x3A (?),0x3B (?),0x3C (?),0x3D (?),0x3E (?),0x3F (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00070150$ PER_TESLA9X45_Part5.per -queue MX_RBCPR_LOG_4"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00070154
tree " MX_RBCPR_LOG_5 [R]                                                0x00070154"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0xFFFFF7FF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print MX_RBCPR_LOG_5 PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.word 0 18.--31. 1 "[31 : 18]  MID_COUNT                           = "
   textline ""
   bitfld.long 0x0   12.--17.     "[17 : 12]  MX_VLEVEL                           = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?),0x08 (?),0x09 (?),0x0A (?),0x0B (?),0x0C (?),0x0D (?),0x0E (?),0x0F (?),0x10 (?),0x11 (?),0x12 (?),0x13 (?),0x14 (?),0x15 (?),0x16 (?),0x17 (?),0x18 (?),0x19 (?),0x1A (?),0x1B (?),0x1C (?),0x1D (?),0x1E (?),0x1F (?),0x20 (?),0x21 (?),0x22 (?),0x23 (?),0x24 (?),0x25 (?),0x26 (?),0x27 (?),0x28 (?),0x29 (?),0x2A (?),0x2B (?),0x2C (?),0x2D (?),0x2E (?),0x2F (?),0x30 (?),0x31 (?),0x32 (?),0x33 (?),0x34 (?),0x35 (?),0x36 (?),0x37 (?),0x38 (?),0x39 (?),0x3A (?),0x3B (?),0x3C (?),0x3D (?),0x3E (?),0x3F (?)"
   textline ""
   bitfld.long 0x0   10.          "[ 10 ]     MAX_FLAG                            = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   9.           "[ 9 ]      UP_FLAG                             = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   8.           "[ 8 ]      MID_FLAG                            = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   7.           "[ 7 ]      DOWN_FLAG                           = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   6.           "[ 6 ]      MIN_FLAG                            = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   0.--5.       "[5 : 0]    VLEVEL                              = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?),0x08 (?),0x09 (?),0x0A (?),0x0B (?),0x0C (?),0x0D (?),0x0E (?),0x0F (?),0x10 (?),0x11 (?),0x12 (?),0x13 (?),0x14 (?),0x15 (?),0x16 (?),0x17 (?),0x18 (?),0x19 (?),0x1A (?),0x1B (?),0x1C (?),0x1D (?),0x1E (?),0x1F (?),0x20 (?),0x21 (?),0x22 (?),0x23 (?),0x24 (?),0x25 (?),0x26 (?),0x27 (?),0x28 (?),0x29 (?),0x2A (?),0x2B (?),0x2C (?),0x2D (?),0x2E (?),0x2F (?),0x30 (?),0x31 (?),0x32 (?),0x33 (?),0x34 (?),0x35 (?),0x36 (?),0x37 (?),0x38 (?),0x39 (?),0x3A (?),0x3B (?),0x3C (?),0x3D (?),0x3E (?),0x3F (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00070154$ PER_TESLA9X45_Part5.per -queue MX_RBCPR_LOG_5"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00070158
tree " MX_RBCPR_LOG_6 [R]                                                0x00070158"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0xFFFFF7FF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print MX_RBCPR_LOG_6 PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.word 0 18.--31. 1 "[31 : 18]  MID_COUNT                           = "
   textline ""
   bitfld.long 0x0   12.--17.     "[17 : 12]  MX_VLEVEL                           = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?),0x08 (?),0x09 (?),0x0A (?),0x0B (?),0x0C (?),0x0D (?),0x0E (?),0x0F (?),0x10 (?),0x11 (?),0x12 (?),0x13 (?),0x14 (?),0x15 (?),0x16 (?),0x17 (?),0x18 (?),0x19 (?),0x1A (?),0x1B (?),0x1C (?),0x1D (?),0x1E (?),0x1F (?),0x20 (?),0x21 (?),0x22 (?),0x23 (?),0x24 (?),0x25 (?),0x26 (?),0x27 (?),0x28 (?),0x29 (?),0x2A (?),0x2B (?),0x2C (?),0x2D (?),0x2E (?),0x2F (?),0x30 (?),0x31 (?),0x32 (?),0x33 (?),0x34 (?),0x35 (?),0x36 (?),0x37 (?),0x38 (?),0x39 (?),0x3A (?),0x3B (?),0x3C (?),0x3D (?),0x3E (?),0x3F (?)"
   textline ""
   bitfld.long 0x0   10.          "[ 10 ]     MAX_FLAG                            = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   9.           "[ 9 ]      UP_FLAG                             = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   8.           "[ 8 ]      MID_FLAG                            = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   7.           "[ 7 ]      DOWN_FLAG                           = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   6.           "[ 6 ]      MIN_FLAG                            = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   0.--5.       "[5 : 0]    VLEVEL                              = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?),0x08 (?),0x09 (?),0x0A (?),0x0B (?),0x0C (?),0x0D (?),0x0E (?),0x0F (?),0x10 (?),0x11 (?),0x12 (?),0x13 (?),0x14 (?),0x15 (?),0x16 (?),0x17 (?),0x18 (?),0x19 (?),0x1A (?),0x1B (?),0x1C (?),0x1D (?),0x1E (?),0x1F (?),0x20 (?),0x21 (?),0x22 (?),0x23 (?),0x24 (?),0x25 (?),0x26 (?),0x27 (?),0x28 (?),0x29 (?),0x2A (?),0x2B (?),0x2C (?),0x2D (?),0x2E (?),0x2F (?),0x30 (?),0x31 (?),0x32 (?),0x33 (?),0x34 (?),0x35 (?),0x36 (?),0x37 (?),0x38 (?),0x39 (?),0x3A (?),0x3B (?),0x3C (?),0x3D (?),0x3E (?),0x3F (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00070158$ PER_TESLA9X45_Part5.per -queue MX_RBCPR_LOG_6"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0007015C
tree " MX_RBCPR_LOG_7 [R]                                                0x0007015C"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0xFFFFF7FF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print MX_RBCPR_LOG_7 PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.word 0 18.--31. 1 "[31 : 18]  MID_COUNT                           = "
   textline ""
   bitfld.long 0x0   12.--17.     "[17 : 12]  MX_VLEVEL                           = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?),0x08 (?),0x09 (?),0x0A (?),0x0B (?),0x0C (?),0x0D (?),0x0E (?),0x0F (?),0x10 (?),0x11 (?),0x12 (?),0x13 (?),0x14 (?),0x15 (?),0x16 (?),0x17 (?),0x18 (?),0x19 (?),0x1A (?),0x1B (?),0x1C (?),0x1D (?),0x1E (?),0x1F (?),0x20 (?),0x21 (?),0x22 (?),0x23 (?),0x24 (?),0x25 (?),0x26 (?),0x27 (?),0x28 (?),0x29 (?),0x2A (?),0x2B (?),0x2C (?),0x2D (?),0x2E (?),0x2F (?),0x30 (?),0x31 (?),0x32 (?),0x33 (?),0x34 (?),0x35 (?),0x36 (?),0x37 (?),0x38 (?),0x39 (?),0x3A (?),0x3B (?),0x3C (?),0x3D (?),0x3E (?),0x3F (?)"
   textline ""
   bitfld.long 0x0   10.          "[ 10 ]     MAX_FLAG                            = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   9.           "[ 9 ]      UP_FLAG                             = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   8.           "[ 8 ]      MID_FLAG                            = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   7.           "[ 7 ]      DOWN_FLAG                           = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   6.           "[ 6 ]      MIN_FLAG                            = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   0.--5.       "[5 : 0]    VLEVEL                              = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?),0x08 (?),0x09 (?),0x0A (?),0x0B (?),0x0C (?),0x0D (?),0x0E (?),0x0F (?),0x10 (?),0x11 (?),0x12 (?),0x13 (?),0x14 (?),0x15 (?),0x16 (?),0x17 (?),0x18 (?),0x19 (?),0x1A (?),0x1B (?),0x1C (?),0x1D (?),0x1E (?),0x1F (?),0x20 (?),0x21 (?),0x22 (?),0x23 (?),0x24 (?),0x25 (?),0x26 (?),0x27 (?),0x28 (?),0x29 (?),0x2A (?),0x2B (?),0x2C (?),0x2D (?),0x2E (?),0x2F (?),0x30 (?),0x31 (?),0x32 (?),0x33 (?),0x34 (?),0x35 (?),0x36 (?),0x37 (?),0x38 (?),0x39 (?),0x3A (?),0x3B (?),0x3C (?),0x3D (?),0x3E (?),0x3F (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0007015C$ PER_TESLA9X45_Part5.per -queue MX_RBCPR_LOG_7"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00070160
tree " MX_RBCPR_HTOL_AGE [RW]                                            0x00070160"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x00000007    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print MX_RBCPR_HTOL_AGE PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   2.           "[ 2 ]      CPR_AGE_DATA_STATUS                 = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   1.           "[ 1 ]      AGE_PAGE                            = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   0.           "[ 0 ]      HTOL_MODE                           = " "0x00 (?),0x01 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00070160$ PER_TESLA9X45_Part5.per -queue MX_RBCPR_HTOL_AGE"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00580000
tree " SNOC_OBS_ID_COREID [R]                                            0x00580000"
  group.long 0x0--0x3
   textline "POR 0x88BBB40D    MASK = 0xFFFFFFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_OBS_ID_COREID PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.long 0 8.--31. 1  "[31 : 8]   CORECHECKSUM                        = "
   textline ""
   hexmask.long.byte 0 0.--7. 1   "[7 : 0]    CORETYPEID                          = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00580000$ PER_TESLA9X45_Part5.per -queue SNOC_OBS_ID_COREID"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00580004
tree " SNOC_OBS_ID_REVISIONID [R]                                        0x00580004"
  group.long 0x0--0x3
   textline "POR 0x00049C00    MASK = 0xFFFFFFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_OBS_ID_REVISIONID PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.long 0 8.--31. 1  "[31 : 8]   FLEXNOCID                           = "
   textline ""
   hexmask.long.byte 0 0.--7. 1   "[7 : 0]    USERID                              = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00580004$ PER_TESLA9X45_Part5.per -queue SNOC_OBS_ID_REVISIONID"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00580008
tree " SNOC_OBS_FAULTEN [RW]                                             0x00580008"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x00000001    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_OBS_FAULTEN PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   0.           "[ 0 ]      FAULTEN                             = " "0x00 (?),0x01 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00580008$ PER_TESLA9X45_Part5.per -queue SNOC_OBS_FAULTEN"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0058000C
tree " SNOC_OBS_ERRVLD [R]                                               0x0058000C"
  group.long 0x0--0x3
   textline "POR 0xDEADBEEF [0xxxxxxxxx]    MASK =  "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_OBS_ERRVLD PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   0.           "[ 0 ]      ERRVLD                              = " "0x00 (?),0x01 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0058000C$ PER_TESLA9X45_Part5.per -queue SNOC_OBS_ERRVLD"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00580010
tree " SNOC_OBS_ERRCLR [RW]                                              0x00580010"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x00000001    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_OBS_ERRCLR PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   0.           "[ 0 ]      ERRCLR                              = " "0x00 (?),0x01 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00580010$ PER_TESLA9X45_Part5.per -queue SNOC_OBS_ERRCLR"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00580014
tree " SNOC_OBS_ERRLOG0 [R]                                              0x00580014"
  group.long 0x0--0x3
   textline "POR 0xDEADBEEF [0xxxxxxxxx]    MASK =  "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_OBS_ERRLOG0 PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   31.          "[ 31 ]     FORMAT                              = " "0x00 (?),0x01 (?)"
   textline ""
   hexmask.long.word 0 16.--25. 1 "[25 : 16]  LEN1                                = "
   textline ""
   bitfld.long 0x0   8.--10.      "[10 : 8]   ERRCODE                             = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?)"
   textline ""
   bitfld.long 0x0   1.--4.       "[4 : 1]    OPC                                 = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?),0x08 (?),0x09 (?),0x0A (?),0x0B (?),0x0C (?),0x0D (?),0x0E (?),0x0F (?)"
   textline ""
   bitfld.long 0x0   0.           "[ 0 ]      LOCK                                = " "0x00 (?),0x01 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00580014$ PER_TESLA9X45_Part5.per -queue SNOC_OBS_ERRLOG0"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00580018
tree " SNOC_OBS_ERRLOG1 [R]                                              0x00580018"
  group.long 0x0--0x3
   textline "POR 0xDEADBEEF [0xxxxxxxxx]    MASK =  "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_OBS_ERRLOG1 PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.long 0 0.--28. 1  "[28 : 0]   ERRLOG1                             = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00580018$ PER_TESLA9X45_Part5.per -queue SNOC_OBS_ERRLOG1"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00580020
tree " SNOC_OBS_ERRLOG3 [R]                                              0x00580020"
  group.long 0x0--0x3
   textline "POR 0xDEADBEEF [0xxxxxxxxx]    MASK =  "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_OBS_ERRLOG3 PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.long 0 0.--31. 1  "[31 : 0]   ERRLOG3                             = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00580020$ PER_TESLA9X45_Part5.per -queue SNOC_OBS_ERRLOG3"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00580024
tree " SNOC_OBS_ERRLOG4 [R]                                              0x00580024"
  group.long 0x0--0x3
   textline "POR 0xDEADBEEF [0xxxxxxxxx]    MASK =  "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_OBS_ERRLOG4 PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   0.           "[ 0 ]      ERRLOG4                             = " "0x00 (?),0x01 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00580024$ PER_TESLA9X45_Part5.per -queue SNOC_OBS_ERRLOG4"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00580028
tree " SNOC_OBS_ERRLOG5 [R]                                              0x00580028"
  group.long 0x0--0x3
   textline "POR 0xDEADBEEF [0xxxxxxxxx]    MASK =  "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_OBS_ERRLOG5 PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.word 0 0.--15. 1  "[15 : 0]   ERRLOG5                             = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00580028$ PER_TESLA9X45_Part5.per -queue SNOC_OBS_ERRLOG5"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00580080
tree " SNOC_OBS_DBG_ID_COREID [R]                                        0x00580080"
  group.long 0x0--0x3
   textline "POR 0x6E075E07    MASK = 0xFFFFFFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_OBS_DBG_ID_COREID PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.long 0 8.--31. 1  "[31 : 8]   CORECHECKSUM                        = "
   textline ""
   hexmask.long.byte 0 0.--7. 1   "[7 : 0]    CORETYPEID                          = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00580080$ PER_TESLA9X45_Part5.per -queue SNOC_OBS_DBG_ID_COREID"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00580084
tree " SNOC_OBS_DBG_ID_REVISIONID [R]                                    0x00580084"
  group.long 0x0--0x3
   textline "POR 0x00049C00    MASK = 0xFFFFFFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_OBS_DBG_ID_REVISIONID PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.long 0 8.--31. 1  "[31 : 8]   FLEXNOCID                           = "
   textline ""
   hexmask.long.byte 0 0.--7. 1   "[7 : 0]    USERID                              = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00580084$ PER_TESLA9X45_Part5.per -queue SNOC_OBS_DBG_ID_REVISIONID"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00580088
tree " SNOC_OBS_DBG_ATBID [RW]                                           0x00580088"
  group.long 0x0--0x3
   textline "POR 0x00000001    MASK = 0x0000007F    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_OBS_DBG_ATBID PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   0.--6.       "[6 : 0]    ATBID                               = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?),0x08 (?),0x09 (?),0x0A (?),0x0B (?),0x0C (?),0x0D (?),0x0E (?),0x0F (?),0x10 (?),0x11 (?),0x12 (?),0x13 (?),0x14 (?),0x15 (?),0x16 (?),0x17 (?),0x18 (?),0x19 (?),0x1A (?),0x1B (?),0x1C (?),0x1D (?),0x1E (?),0x1F (?),0x20 (?),0x21 (?),0x22 (?),0x23 (?),0x24 (?),0x25 (?),0x26 (?),0x27 (?),0x28 (?),0x29 (?),0x2A (?),0x2B (?),0x2C (?),0x2D (?),0x2E (?),0x2F (?),0x30 (?),0x31 (?),0x32 (?),0x33 (?),0x34 (?),0x35 (?),0x36 (?),0x37 (?),0x38 (?),0x39 (?),0x3A (?),0x3B (?),0x3C (?),0x3D (?),0x3E (?),0x3F (?),0x40 (?),0x41 (?),0x42 (?),0x43 (?),0x44 (?),0x45 (?),0x46 (?),0x47 (?),0x48 (?),0x49 (?),0x4A (?),0x4B (?),0x4C (?),0x4D (?),0x4E (?),0x4F (?),0x50 (?),0x51 (?),0x52 (?),0x53 (?),0x54 (?),0x55 (?),0x56 (?),0x57 (?),0x58 (?),0x59 (?),0x5A (?),0x5B (?),0x5C (?),0x5D (?),0x5E (?),0x5F (?),0x60 (?),0x61 (?),0x62 (?),0x63 (?),0x64 (?),0x65 (?),0x66 (?),0x67 (?),0x68 (?),0x69 (?),0x6A (?),0x6B (?),0x6C (?),0x6D (?),0x6E (?),0x6F (?),0x70 (?),0x71 (?),0x72 (?),0x73 (?),0x74 (?),0x75 (?),0x76 (?),0x77 (?),0x78 (?),0x79 (?),0x7A (?),0x7B (?),0x7C (?),0x7D (?),0x7E (?),0x7F (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00580088$ PER_TESLA9X45_Part5.per -queue SNOC_OBS_DBG_ATBID"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0058008C
tree " SNOC_OBS_DBG_ATBEN [RW]                                           0x0058008C"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x00000001    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_OBS_DBG_ATBEN PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   0.           "[ 0 ]      ATBEN                               = " "0x00 (?),0x01 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0058008C$ PER_TESLA9X45_Part5.per -queue SNOC_OBS_DBG_ATBEN"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00580090
tree " SNOC_OBS_DBG_SYNCPERIOD [RW]                                      0x00580090"
  group.long 0x0--0x3
   textline "POR 0x00000008    MASK = 0x0000001F    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_OBS_DBG_SYNCPERIOD PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   0.--4.       "[4 : 0]    SYNCPERIOD                          = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?),0x08 (?),0x09 (?),0x0A (?),0x0B (?),0x0C (?),0x0D (?),0x0E (?),0x0F (?),0x10 (?),0x11 (?),0x12 (?),0x13 (?),0x14 (?),0x15 (?),0x16 (?),0x17 (?),0x18 (?),0x19 (?),0x1A (?),0x1B (?),0x1C (?),0x1D (?),0x1E (?),0x1F (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00580090$ PER_TESLA9X45_Part5.per -queue SNOC_OBS_DBG_SYNCPERIOD"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00581080
tree " SNOC_MSS_CRYPTO_NAV_DBG_TFILT_ID_COREID [R]                       0x00581080"
  group.long 0x0--0x3
   textline "POR 0x2E41D909    MASK = 0xFFFFFFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_MSS_CRYPTO_NAV_DBG_TFILT_ID_COREID PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.long 0 8.--31. 1  "[31 : 8]   CORECHECKSUM                        = "
   textline ""
   hexmask.long.byte 0 0.--7. 1   "[7 : 0]    CORETYPEID                          = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00581080$ PER_TESLA9X45_Part5.per -queue SNOC_MSS_CRYPTO_NAV_DBG_TFILT_ID_COREID"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00581084
tree " SNOC_MSS_CRYPTO_NAV_DBG_TFILT_ID_REVISIONID [R]                   0x00581084"
  group.long 0x0--0x3
   textline "POR 0x00049C00    MASK = 0xFFFFFFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_MSS_CRYPTO_NAV_DBG_TFILT_ID_REVISIONID PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.long 0 8.--31. 1  "[31 : 8]   FLEXNOCID                           = "
   textline ""
   hexmask.long.byte 0 0.--7. 1   "[7 : 0]    USERID                              = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00581084$ PER_TESLA9X45_Part5.per -queue SNOC_MSS_CRYPTO_NAV_DBG_TFILT_ID_REVISIONID"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00581088
tree " SNOC_MSS_CRYPTO_NAV_DBG_TFILT_MODE [RW]                           0x00581088"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x00000001    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_MSS_CRYPTO_NAV_DBG_TFILT_MODE PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   0.           "[ 0 ]      MODE                                = " "0x00 (?),0x01 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00581088$ PER_TESLA9X45_Part5.per -queue SNOC_MSS_CRYPTO_NAV_DBG_TFILT_MODE"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0058108C
tree " SNOC_MSS_CRYPTO_NAV_DBG_TFILT_ADDRBASE_LOW [RW]                   0x0058108C"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0xFFFFFFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_MSS_CRYPTO_NAV_DBG_TFILT_ADDRBASE_LOW PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.long 0 0.--31. 1  "[31 : 0]   ADDRBASE_LOW                        = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0058108C$ PER_TESLA9X45_Part5.per -queue SNOC_MSS_CRYPTO_NAV_DBG_TFILT_ADDRBASE_LOW"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00581090
tree " SNOC_MSS_CRYPTO_NAV_DBG_TFILT_ADDRBASE_HIGH [RW]                  0x00581090"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x00000001    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_MSS_CRYPTO_NAV_DBG_TFILT_ADDRBASE_HIGH PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   0.           "[ 0 ]      ADDRBASE_HIGH                       = " "0x00 (?),0x01 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00581090$ PER_TESLA9X45_Part5.per -queue SNOC_MSS_CRYPTO_NAV_DBG_TFILT_ADDRBASE_HIGH"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00581094
tree " SNOC_MSS_CRYPTO_NAV_DBG_TFILT_ADDRWINDOWSIZE [RW]                 0x00581094"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x0000003F    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_MSS_CRYPTO_NAV_DBG_TFILT_ADDRWINDOWSIZE PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   0.--5.       "[5 : 0]    ADDRWINDOWSIZE                      = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?),0x08 (?),0x09 (?),0x0A (?),0x0B (?),0x0C (?),0x0D (?),0x0E (?),0x0F (?),0x10 (?),0x11 (?),0x12 (?),0x13 (?),0x14 (?),0x15 (?),0x16 (?),0x17 (?),0x18 (?),0x19 (?),0x1A (?),0x1B (?),0x1C (?),0x1D (?),0x1E (?),0x1F (?),0x20 (?),0x21 (?),0x22 (?),0x23 (?),0x24 (?),0x25 (?),0x26 (?),0x27 (?),0x28 (?),0x29 (?),0x2A (?),0x2B (?),0x2C (?),0x2D (?),0x2E (?),0x2F (?),0x30 (?),0x31 (?),0x32 (?),0x33 (?),0x34 (?),0x35 (?),0x36 (?),0x37 (?),0x38 (?),0x39 (?),0x3A (?),0x3B (?),0x3C (?),0x3D (?),0x3E (?),0x3F (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00581094$ PER_TESLA9X45_Part5.per -queue SNOC_MSS_CRYPTO_NAV_DBG_TFILT_ADDRWINDOWSIZE"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00581098
tree " SNOC_MSS_CRYPTO_NAV_DBG_TFILT_SRCIDBASE [RW]                      0x00581098"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x00007FFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_MSS_CRYPTO_NAV_DBG_TFILT_SRCIDBASE PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.word 0 0.--14. 1  "[14 : 0]   SRCIDBASE                           = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00581098$ PER_TESLA9X45_Part5.per -queue SNOC_MSS_CRYPTO_NAV_DBG_TFILT_SRCIDBASE"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0058109C
tree " SNOC_MSS_CRYPTO_NAV_DBG_TFILT_SRCIDMASK [RW]                      0x0058109C"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x00007FFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_MSS_CRYPTO_NAV_DBG_TFILT_SRCIDMASK PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.word 0 0.--14. 1  "[14 : 0]   SRCIDMASK                           = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0058109C$ PER_TESLA9X45_Part5.per -queue SNOC_MSS_CRYPTO_NAV_DBG_TFILT_SRCIDMASK"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x005810A0
tree " SNOC_MSS_CRYPTO_NAV_DBG_TFILT_OPCODE [RW]                         0x005810A0"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x00000003    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_MSS_CRYPTO_NAV_DBG_TFILT_OPCODE PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   1.           "[ 1 ]      WREN                                = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   0.           "[ 0 ]      RDEN                                = " "0x00 (?),0x01 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x005810A0$ PER_TESLA9X45_Part5.per -queue SNOC_MSS_CRYPTO_NAV_DBG_TFILT_OPCODE"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x005810A4
tree " SNOC_MSS_CRYPTO_NAV_DBG_TFILT_USERBASE [RW]                       0x005810A4"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x0000FFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_MSS_CRYPTO_NAV_DBG_TFILT_USERBASE PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.word 0 0.--15. 1  "[15 : 0]   USERBASE                            = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x005810A4$ PER_TESLA9X45_Part5.per -queue SNOC_MSS_CRYPTO_NAV_DBG_TFILT_USERBASE"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x005810A8
tree " SNOC_MSS_CRYPTO_NAV_DBG_TFILT_USERMASK [RW]                       0x005810A8"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x0000FFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_MSS_CRYPTO_NAV_DBG_TFILT_USERMASK PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.word 0 0.--15. 1  "[15 : 0]   USERMASK                            = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x005810A8$ PER_TESLA9X45_Part5.per -queue SNOC_MSS_CRYPTO_NAV_DBG_TFILT_USERMASK"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00581100
tree " SNOC_USB3_TFILT_ID_COREID [R]                                     0x00581100"
  group.long 0x0--0x3
   textline "POR 0x82D78309    MASK = 0xFFFFFFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_USB3_TFILT_ID_COREID PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.long 0 8.--31. 1  "[31 : 8]   CORECHECKSUM                        = "
   textline ""
   hexmask.long.byte 0 0.--7. 1   "[7 : 0]    CORETYPEID                          = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00581100$ PER_TESLA9X45_Part5.per -queue SNOC_USB3_TFILT_ID_COREID"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00581104
tree " SNOC_USB3_TFILT_ID_REVISIONID [R]                                 0x00581104"
  group.long 0x0--0x3
   textline "POR 0x00049C00    MASK = 0xFFFFFFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_USB3_TFILT_ID_REVISIONID PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.long 0 8.--31. 1  "[31 : 8]   FLEXNOCID                           = "
   textline ""
   hexmask.long.byte 0 0.--7. 1   "[7 : 0]    USERID                              = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00581104$ PER_TESLA9X45_Part5.per -queue SNOC_USB3_TFILT_ID_REVISIONID"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00581108
tree " SNOC_USB3_TFILT_MODE [RW]                                         0x00581108"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x00000001    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_USB3_TFILT_MODE PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   0.           "[ 0 ]      MODE                                = " "0x00 (?),0x01 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00581108$ PER_TESLA9X45_Part5.per -queue SNOC_USB3_TFILT_MODE"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0058110C
tree " SNOC_USB3_TFILT_ADDRBASE_LOW [RW]                                 0x0058110C"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0xFFFFFFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_USB3_TFILT_ADDRBASE_LOW PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.long 0 0.--31. 1  "[31 : 0]   ADDRBASE_LOW                        = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0058110C$ PER_TESLA9X45_Part5.per -queue SNOC_USB3_TFILT_ADDRBASE_LOW"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00581114
tree " SNOC_USB3_TFILT_ADDRWINDOWSIZE [RW]                               0x00581114"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x0000003F    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_USB3_TFILT_ADDRWINDOWSIZE PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   0.--5.       "[5 : 0]    ADDRWINDOWSIZE                      = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?),0x08 (?),0x09 (?),0x0A (?),0x0B (?),0x0C (?),0x0D (?),0x0E (?),0x0F (?),0x10 (?),0x11 (?),0x12 (?),0x13 (?),0x14 (?),0x15 (?),0x16 (?),0x17 (?),0x18 (?),0x19 (?),0x1A (?),0x1B (?),0x1C (?),0x1D (?),0x1E (?),0x1F (?),0x20 (?),0x21 (?),0x22 (?),0x23 (?),0x24 (?),0x25 (?),0x26 (?),0x27 (?),0x28 (?),0x29 (?),0x2A (?),0x2B (?),0x2C (?),0x2D (?),0x2E (?),0x2F (?),0x30 (?),0x31 (?),0x32 (?),0x33 (?),0x34 (?),0x35 (?),0x36 (?),0x37 (?),0x38 (?),0x39 (?),0x3A (?),0x3B (?),0x3C (?),0x3D (?),0x3E (?),0x3F (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00581114$ PER_TESLA9X45_Part5.per -queue SNOC_USB3_TFILT_ADDRWINDOWSIZE"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00581118
tree " SNOC_USB3_TFILT_SRCIDBASE [RW]                                    0x00581118"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x00007FFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_USB3_TFILT_SRCIDBASE PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.word 0 0.--14. 1  "[14 : 0]   SRCIDBASE                           = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00581118$ PER_TESLA9X45_Part5.per -queue SNOC_USB3_TFILT_SRCIDBASE"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0058111C
tree " SNOC_USB3_TFILT_SRCIDMASK [RW]                                    0x0058111C"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x00007FFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_USB3_TFILT_SRCIDMASK PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.word 0 0.--14. 1  "[14 : 0]   SRCIDMASK                           = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0058111C$ PER_TESLA9X45_Part5.per -queue SNOC_USB3_TFILT_SRCIDMASK"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00581120
tree " SNOC_USB3_TFILT_OPCODE [RW]                                       0x00581120"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x00000003    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_USB3_TFILT_OPCODE PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   1.           "[ 1 ]      WREN                                = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   0.           "[ 0 ]      RDEN                                = " "0x00 (?),0x01 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00581120$ PER_TESLA9X45_Part5.per -queue SNOC_USB3_TFILT_OPCODE"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00581124
tree " SNOC_USB3_TFILT_USERBASE [RW]                                     0x00581124"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x0000FFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_USB3_TFILT_USERBASE PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.word 0 0.--15. 1  "[15 : 0]   USERBASE                            = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00581124$ PER_TESLA9X45_Part5.per -queue SNOC_USB3_TFILT_USERBASE"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00581128
tree " SNOC_USB3_TFILT_USERMASK [RW]                                     0x00581128"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x0000FFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_USB3_TFILT_USERMASK PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.word 0 0.--15. 1  "[15 : 0]   USERMASK                            = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00581128$ PER_TESLA9X45_Part5.per -queue SNOC_USB3_TFILT_USERMASK"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00581180
tree " SNOC_PCIE_TFILT_ID_COREID [R]                                     0x00581180"
  group.long 0x0--0x3
   textline "POR 0xEF1E2A09    MASK = 0xFFFFFFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_PCIE_TFILT_ID_COREID PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.long 0 8.--31. 1  "[31 : 8]   CORECHECKSUM                        = "
   textline ""
   hexmask.long.byte 0 0.--7. 1   "[7 : 0]    CORETYPEID                          = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00581180$ PER_TESLA9X45_Part5.per -queue SNOC_PCIE_TFILT_ID_COREID"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00581184
tree " SNOC_PCIE_TFILT_ID_REVISIONID [R]                                 0x00581184"
  group.long 0x0--0x3
   textline "POR 0x00049C00    MASK = 0xFFFFFFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_PCIE_TFILT_ID_REVISIONID PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.long 0 8.--31. 1  "[31 : 8]   FLEXNOCID                           = "
   textline ""
   hexmask.long.byte 0 0.--7. 1   "[7 : 0]    USERID                              = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00581184$ PER_TESLA9X45_Part5.per -queue SNOC_PCIE_TFILT_ID_REVISIONID"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00581188
tree " SNOC_PCIE_TFILT_MODE [RW]                                         0x00581188"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x00000001    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_PCIE_TFILT_MODE PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   0.           "[ 0 ]      MODE                                = " "0x00 (?),0x01 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00581188$ PER_TESLA9X45_Part5.per -queue SNOC_PCIE_TFILT_MODE"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0058118C
tree " SNOC_PCIE_TFILT_ADDRBASE_LOW [RW]                                 0x0058118C"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0xFFFFFFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_PCIE_TFILT_ADDRBASE_LOW PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.long 0 0.--31. 1  "[31 : 0]   ADDRBASE_LOW                        = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0058118C$ PER_TESLA9X45_Part5.per -queue SNOC_PCIE_TFILT_ADDRBASE_LOW"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00581194
tree " SNOC_PCIE_TFILT_ADDRWINDOWSIZE [RW]                               0x00581194"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x0000003F    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_PCIE_TFILT_ADDRWINDOWSIZE PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   0.--5.       "[5 : 0]    ADDRWINDOWSIZE                      = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?),0x08 (?),0x09 (?),0x0A (?),0x0B (?),0x0C (?),0x0D (?),0x0E (?),0x0F (?),0x10 (?),0x11 (?),0x12 (?),0x13 (?),0x14 (?),0x15 (?),0x16 (?),0x17 (?),0x18 (?),0x19 (?),0x1A (?),0x1B (?),0x1C (?),0x1D (?),0x1E (?),0x1F (?),0x20 (?),0x21 (?),0x22 (?),0x23 (?),0x24 (?),0x25 (?),0x26 (?),0x27 (?),0x28 (?),0x29 (?),0x2A (?),0x2B (?),0x2C (?),0x2D (?),0x2E (?),0x2F (?),0x30 (?),0x31 (?),0x32 (?),0x33 (?),0x34 (?),0x35 (?),0x36 (?),0x37 (?),0x38 (?),0x39 (?),0x3A (?),0x3B (?),0x3C (?),0x3D (?),0x3E (?),0x3F (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00581194$ PER_TESLA9X45_Part5.per -queue SNOC_PCIE_TFILT_ADDRWINDOWSIZE"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00581198
tree " SNOC_PCIE_TFILT_SRCIDBASE [RW]                                    0x00581198"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x00007FFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_PCIE_TFILT_SRCIDBASE PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.word 0 0.--14. 1  "[14 : 0]   SRCIDBASE                           = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00581198$ PER_TESLA9X45_Part5.per -queue SNOC_PCIE_TFILT_SRCIDBASE"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0058119C
tree " SNOC_PCIE_TFILT_SRCIDMASK [RW]                                    0x0058119C"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x00007FFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_PCIE_TFILT_SRCIDMASK PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.word 0 0.--14. 1  "[14 : 0]   SRCIDMASK                           = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0058119C$ PER_TESLA9X45_Part5.per -queue SNOC_PCIE_TFILT_SRCIDMASK"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x005811A0
tree " SNOC_PCIE_TFILT_OPCODE [RW]                                       0x005811A0"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x00000003    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_PCIE_TFILT_OPCODE PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   1.           "[ 1 ]      WREN                                = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   0.           "[ 0 ]      RDEN                                = " "0x00 (?),0x01 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x005811A0$ PER_TESLA9X45_Part5.per -queue SNOC_PCIE_TFILT_OPCODE"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x005811A4
tree " SNOC_PCIE_TFILT_USERBASE [RW]                                     0x005811A4"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x0000FFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_PCIE_TFILT_USERBASE PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.word 0 0.--15. 1  "[15 : 0]   USERBASE                            = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x005811A4$ PER_TESLA9X45_Part5.per -queue SNOC_PCIE_TFILT_USERBASE"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x005811A8
tree " SNOC_PCIE_TFILT_USERMASK [RW]                                     0x005811A8"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x0000FFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_PCIE_TFILT_USERMASK PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.word 0 0.--15. 1  "[15 : 0]   USERMASK                            = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x005811A8$ PER_TESLA9X45_Part5.per -queue SNOC_PCIE_TFILT_USERMASK"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00581200
tree " SNOC_QDSS_BAM_TFILT_ID_COREID [R]                                 0x00581200"
  group.long 0x0--0x3
   textline "POR 0xB5500509    MASK = 0xFFFFFFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_QDSS_BAM_TFILT_ID_COREID PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.long 0 8.--31. 1  "[31 : 8]   CORECHECKSUM                        = "
   textline ""
   hexmask.long.byte 0 0.--7. 1   "[7 : 0]    CORETYPEID                          = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00581200$ PER_TESLA9X45_Part5.per -queue SNOC_QDSS_BAM_TFILT_ID_COREID"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00581204
tree " SNOC_QDSS_BAM_TFILT_ID_REVISIONID [R]                             0x00581204"
  group.long 0x0--0x3
   textline "POR 0x00049C00    MASK = 0xFFFFFFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_QDSS_BAM_TFILT_ID_REVISIONID PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.long 0 8.--31. 1  "[31 : 8]   FLEXNOCID                           = "
   textline ""
   hexmask.long.byte 0 0.--7. 1   "[7 : 0]    USERID                              = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00581204$ PER_TESLA9X45_Part5.per -queue SNOC_QDSS_BAM_TFILT_ID_REVISIONID"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00581208
tree " SNOC_QDSS_BAM_TFILT_MODE [RW]                                     0x00581208"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x00000001    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_QDSS_BAM_TFILT_MODE PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   0.           "[ 0 ]      MODE                                = " "0x00 (?),0x01 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00581208$ PER_TESLA9X45_Part5.per -queue SNOC_QDSS_BAM_TFILT_MODE"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0058120C
tree " SNOC_QDSS_BAM_TFILT_ADDRBASE_LOW [RW]                             0x0058120C"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0xFFFFFFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_QDSS_BAM_TFILT_ADDRBASE_LOW PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.long 0 0.--31. 1  "[31 : 0]   ADDRBASE_LOW                        = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0058120C$ PER_TESLA9X45_Part5.per -queue SNOC_QDSS_BAM_TFILT_ADDRBASE_LOW"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00581214
tree " SNOC_QDSS_BAM_TFILT_ADDRWINDOWSIZE [RW]                           0x00581214"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x0000003F    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_QDSS_BAM_TFILT_ADDRWINDOWSIZE PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   0.--5.       "[5 : 0]    ADDRWINDOWSIZE                      = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?),0x08 (?),0x09 (?),0x0A (?),0x0B (?),0x0C (?),0x0D (?),0x0E (?),0x0F (?),0x10 (?),0x11 (?),0x12 (?),0x13 (?),0x14 (?),0x15 (?),0x16 (?),0x17 (?),0x18 (?),0x19 (?),0x1A (?),0x1B (?),0x1C (?),0x1D (?),0x1E (?),0x1F (?),0x20 (?),0x21 (?),0x22 (?),0x23 (?),0x24 (?),0x25 (?),0x26 (?),0x27 (?),0x28 (?),0x29 (?),0x2A (?),0x2B (?),0x2C (?),0x2D (?),0x2E (?),0x2F (?),0x30 (?),0x31 (?),0x32 (?),0x33 (?),0x34 (?),0x35 (?),0x36 (?),0x37 (?),0x38 (?),0x39 (?),0x3A (?),0x3B (?),0x3C (?),0x3D (?),0x3E (?),0x3F (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00581214$ PER_TESLA9X45_Part5.per -queue SNOC_QDSS_BAM_TFILT_ADDRWINDOWSIZE"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00581218
tree " SNOC_QDSS_BAM_TFILT_SRCIDBASE [RW]                                0x00581218"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x00007FFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_QDSS_BAM_TFILT_SRCIDBASE PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.word 0 0.--14. 1  "[14 : 0]   SRCIDBASE                           = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00581218$ PER_TESLA9X45_Part5.per -queue SNOC_QDSS_BAM_TFILT_SRCIDBASE"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0058121C
tree " SNOC_QDSS_BAM_TFILT_SRCIDMASK [RW]                                0x0058121C"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x00007FFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_QDSS_BAM_TFILT_SRCIDMASK PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.word 0 0.--14. 1  "[14 : 0]   SRCIDMASK                           = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0058121C$ PER_TESLA9X45_Part5.per -queue SNOC_QDSS_BAM_TFILT_SRCIDMASK"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00581220
tree " SNOC_QDSS_BAM_TFILT_OPCODE [RW]                                   0x00581220"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x00000003    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_QDSS_BAM_TFILT_OPCODE PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   1.           "[ 1 ]      WREN                                = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   0.           "[ 0 ]      RDEN                                = " "0x00 (?),0x01 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00581220$ PER_TESLA9X45_Part5.per -queue SNOC_QDSS_BAM_TFILT_OPCODE"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00581224
tree " SNOC_QDSS_BAM_TFILT_USERBASE [RW]                                 0x00581224"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x0000FFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_QDSS_BAM_TFILT_USERBASE PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.word 0 0.--15. 1  "[15 : 0]   USERBASE                            = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00581224$ PER_TESLA9X45_Part5.per -queue SNOC_QDSS_BAM_TFILT_USERBASE"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00581228
tree " SNOC_QDSS_BAM_TFILT_USERMASK [RW]                                 0x00581228"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x0000FFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_QDSS_BAM_TFILT_USERMASK PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.word 0 0.--15. 1  "[15 : 0]   USERMASK                            = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00581228$ PER_TESLA9X45_Part5.per -queue SNOC_QDSS_BAM_TFILT_USERMASK"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00581280
tree " SNOC_PCNOC_TFILT_ID_COREID [R]                                    0x00581280"
  group.long 0x0--0x3
   textline "POR 0x5E04A609    MASK = 0xFFFFFFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_PCNOC_TFILT_ID_COREID PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.long 0 8.--31. 1  "[31 : 8]   CORECHECKSUM                        = "
   textline ""
   hexmask.long.byte 0 0.--7. 1   "[7 : 0]    CORETYPEID                          = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00581280$ PER_TESLA9X45_Part5.per -queue SNOC_PCNOC_TFILT_ID_COREID"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00581284
tree " SNOC_PCNOC_TFILT_ID_REVISIONID [R]                                0x00581284"
  group.long 0x0--0x3
   textline "POR 0x00049C00    MASK = 0xFFFFFFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_PCNOC_TFILT_ID_REVISIONID PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.long 0 8.--31. 1  "[31 : 8]   FLEXNOCID                           = "
   textline ""
   hexmask.long.byte 0 0.--7. 1   "[7 : 0]    USERID                              = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00581284$ PER_TESLA9X45_Part5.per -queue SNOC_PCNOC_TFILT_ID_REVISIONID"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00581288
tree " SNOC_PCNOC_TFILT_MODE [RW]                                        0x00581288"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x00000001    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_PCNOC_TFILT_MODE PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   0.           "[ 0 ]      MODE                                = " "0x00 (?),0x01 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00581288$ PER_TESLA9X45_Part5.per -queue SNOC_PCNOC_TFILT_MODE"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0058128C
tree " SNOC_PCNOC_TFILT_ADDRBASE_LOW [RW]                                0x0058128C"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0xFFFFFFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_PCNOC_TFILT_ADDRBASE_LOW PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.long 0 0.--31. 1  "[31 : 0]   ADDRBASE_LOW                        = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0058128C$ PER_TESLA9X45_Part5.per -queue SNOC_PCNOC_TFILT_ADDRBASE_LOW"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00581290
tree " SNOC_PCNOC_TFILT_ADDRBASE_HIGH [RW]                               0x00581290"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x00000001    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_PCNOC_TFILT_ADDRBASE_HIGH PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   0.           "[ 0 ]      ADDRBASE_HIGH                       = " "0x00 (?),0x01 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00581290$ PER_TESLA9X45_Part5.per -queue SNOC_PCNOC_TFILT_ADDRBASE_HIGH"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00581294
tree " SNOC_PCNOC_TFILT_ADDRWINDOWSIZE [RW]                              0x00581294"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x0000003F    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_PCNOC_TFILT_ADDRWINDOWSIZE PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   0.--5.       "[5 : 0]    ADDRWINDOWSIZE                      = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?),0x08 (?),0x09 (?),0x0A (?),0x0B (?),0x0C (?),0x0D (?),0x0E (?),0x0F (?),0x10 (?),0x11 (?),0x12 (?),0x13 (?),0x14 (?),0x15 (?),0x16 (?),0x17 (?),0x18 (?),0x19 (?),0x1A (?),0x1B (?),0x1C (?),0x1D (?),0x1E (?),0x1F (?),0x20 (?),0x21 (?),0x22 (?),0x23 (?),0x24 (?),0x25 (?),0x26 (?),0x27 (?),0x28 (?),0x29 (?),0x2A (?),0x2B (?),0x2C (?),0x2D (?),0x2E (?),0x2F (?),0x30 (?),0x31 (?),0x32 (?),0x33 (?),0x34 (?),0x35 (?),0x36 (?),0x37 (?),0x38 (?),0x39 (?),0x3A (?),0x3B (?),0x3C (?),0x3D (?),0x3E (?),0x3F (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00581294$ PER_TESLA9X45_Part5.per -queue SNOC_PCNOC_TFILT_ADDRWINDOWSIZE"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00581298
tree " SNOC_PCNOC_TFILT_SRCIDBASE [RW]                                   0x00581298"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x00007FFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_PCNOC_TFILT_SRCIDBASE PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.word 0 0.--14. 1  "[14 : 0]   SRCIDBASE                           = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00581298$ PER_TESLA9X45_Part5.per -queue SNOC_PCNOC_TFILT_SRCIDBASE"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0058129C
tree " SNOC_PCNOC_TFILT_SRCIDMASK [RW]                                   0x0058129C"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x00007FFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_PCNOC_TFILT_SRCIDMASK PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.word 0 0.--14. 1  "[14 : 0]   SRCIDMASK                           = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0058129C$ PER_TESLA9X45_Part5.per -queue SNOC_PCNOC_TFILT_SRCIDMASK"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x005812A0
tree " SNOC_PCNOC_TFILT_OPCODE [RW]                                      0x005812A0"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x00000003    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_PCNOC_TFILT_OPCODE PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   1.           "[ 1 ]      WREN                                = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   0.           "[ 0 ]      RDEN                                = " "0x00 (?),0x01 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x005812A0$ PER_TESLA9X45_Part5.per -queue SNOC_PCNOC_TFILT_OPCODE"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x005812A4
tree " SNOC_PCNOC_TFILT_USERBASE [RW]                                    0x005812A4"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x0000FFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_PCNOC_TFILT_USERBASE PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.word 0 0.--15. 1  "[15 : 0]   USERBASE                            = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x005812A4$ PER_TESLA9X45_Part5.per -queue SNOC_PCNOC_TFILT_USERBASE"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x005812A8
tree " SNOC_PCNOC_TFILT_USERMASK [RW]                                    0x005812A8"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x0000FFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_PCNOC_TFILT_USERMASK PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.word 0 0.--15. 1  "[15 : 0]   USERMASK                            = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x005812A8$ PER_TESLA9X45_Part5.per -queue SNOC_PCNOC_TFILT_USERMASK"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00581300
tree " SNOC_BIMC_TFILT_ID_COREID [R]                                     0x00581300"
  group.long 0x0--0x3
   textline "POR 0xE7F8D409    MASK = 0xFFFFFFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_BIMC_TFILT_ID_COREID PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.long 0 8.--31. 1  "[31 : 8]   CORECHECKSUM                        = "
   textline ""
   hexmask.long.byte 0 0.--7. 1   "[7 : 0]    CORETYPEID                          = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00581300$ PER_TESLA9X45_Part5.per -queue SNOC_BIMC_TFILT_ID_COREID"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00581304
tree " SNOC_BIMC_TFILT_ID_REVISIONID [R]                                 0x00581304"
  group.long 0x0--0x3
   textline "POR 0x00049C00    MASK = 0xFFFFFFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_BIMC_TFILT_ID_REVISIONID PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.long 0 8.--31. 1  "[31 : 8]   FLEXNOCID                           = "
   textline ""
   hexmask.long.byte 0 0.--7. 1   "[7 : 0]    USERID                              = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00581304$ PER_TESLA9X45_Part5.per -queue SNOC_BIMC_TFILT_ID_REVISIONID"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00581308
tree " SNOC_BIMC_TFILT_MODE [RW]                                         0x00581308"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x00000001    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_BIMC_TFILT_MODE PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   0.           "[ 0 ]      MODE                                = " "0x00 (?),0x01 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00581308$ PER_TESLA9X45_Part5.per -queue SNOC_BIMC_TFILT_MODE"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0058130C
tree " SNOC_BIMC_TFILT_ADDRBASE_LOW [RW]                                 0x0058130C"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0xFFFFFFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_BIMC_TFILT_ADDRBASE_LOW PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.long 0 0.--31. 1  "[31 : 0]   ADDRBASE_LOW                        = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0058130C$ PER_TESLA9X45_Part5.per -queue SNOC_BIMC_TFILT_ADDRBASE_LOW"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00581310
tree " SNOC_BIMC_TFILT_ADDRBASE_HIGH [RW]                                0x00581310"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x00000001    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_BIMC_TFILT_ADDRBASE_HIGH PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   0.           "[ 0 ]      ADDRBASE_HIGH                       = " "0x00 (?),0x01 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00581310$ PER_TESLA9X45_Part5.per -queue SNOC_BIMC_TFILT_ADDRBASE_HIGH"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00581314
tree " SNOC_BIMC_TFILT_ADDRWINDOWSIZE [RW]                               0x00581314"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x0000003F    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_BIMC_TFILT_ADDRWINDOWSIZE PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   0.--5.       "[5 : 0]    ADDRWINDOWSIZE                      = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?),0x08 (?),0x09 (?),0x0A (?),0x0B (?),0x0C (?),0x0D (?),0x0E (?),0x0F (?),0x10 (?),0x11 (?),0x12 (?),0x13 (?),0x14 (?),0x15 (?),0x16 (?),0x17 (?),0x18 (?),0x19 (?),0x1A (?),0x1B (?),0x1C (?),0x1D (?),0x1E (?),0x1F (?),0x20 (?),0x21 (?),0x22 (?),0x23 (?),0x24 (?),0x25 (?),0x26 (?),0x27 (?),0x28 (?),0x29 (?),0x2A (?),0x2B (?),0x2C (?),0x2D (?),0x2E (?),0x2F (?),0x30 (?),0x31 (?),0x32 (?),0x33 (?),0x34 (?),0x35 (?),0x36 (?),0x37 (?),0x38 (?),0x39 (?),0x3A (?),0x3B (?),0x3C (?),0x3D (?),0x3E (?),0x3F (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00581314$ PER_TESLA9X45_Part5.per -queue SNOC_BIMC_TFILT_ADDRWINDOWSIZE"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00581318
tree " SNOC_BIMC_TFILT_SRCIDBASE [RW]                                    0x00581318"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x00007FFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_BIMC_TFILT_SRCIDBASE PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.word 0 0.--14. 1  "[14 : 0]   SRCIDBASE                           = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00581318$ PER_TESLA9X45_Part5.per -queue SNOC_BIMC_TFILT_SRCIDBASE"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0058131C
tree " SNOC_BIMC_TFILT_SRCIDMASK [RW]                                    0x0058131C"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x00007FFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_BIMC_TFILT_SRCIDMASK PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.word 0 0.--14. 1  "[14 : 0]   SRCIDMASK                           = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0058131C$ PER_TESLA9X45_Part5.per -queue SNOC_BIMC_TFILT_SRCIDMASK"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00581320
tree " SNOC_BIMC_TFILT_OPCODE [RW]                                       0x00581320"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x00000003    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_BIMC_TFILT_OPCODE PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   1.           "[ 1 ]      WREN                                = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   0.           "[ 0 ]      RDEN                                = " "0x00 (?),0x01 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00581320$ PER_TESLA9X45_Part5.per -queue SNOC_BIMC_TFILT_OPCODE"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00581324
tree " SNOC_BIMC_TFILT_USERBASE [RW]                                     0x00581324"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x0000FFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_BIMC_TFILT_USERBASE PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.word 0 0.--15. 1  "[15 : 0]   USERBASE                            = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00581324$ PER_TESLA9X45_Part5.per -queue SNOC_BIMC_TFILT_USERBASE"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00581328
tree " SNOC_BIMC_TFILT_USERMASK [RW]                                     0x00581328"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x0000FFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_BIMC_TFILT_USERMASK PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.word 0 0.--15. 1  "[15 : 0]   USERMASK                            = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00581328$ PER_TESLA9X45_Part5.per -queue SNOC_BIMC_TFILT_USERMASK"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00581380
tree " SNOC_IPA_TFILT_ID_COREID [R]                                      0x00581380"
  group.long 0x0--0x3
   textline "POR 0x30706C09    MASK = 0xFFFFFFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_IPA_TFILT_ID_COREID PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.long 0 8.--31. 1  "[31 : 8]   CORECHECKSUM                        = "
   textline ""
   hexmask.long.byte 0 0.--7. 1   "[7 : 0]    CORETYPEID                          = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00581380$ PER_TESLA9X45_Part5.per -queue SNOC_IPA_TFILT_ID_COREID"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00581384
tree " SNOC_IPA_TFILT_ID_REVISIONID [R]                                  0x00581384"
  group.long 0x0--0x3
   textline "POR 0x00049C00    MASK = 0xFFFFFFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_IPA_TFILT_ID_REVISIONID PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.long 0 8.--31. 1  "[31 : 8]   FLEXNOCID                           = "
   textline ""
   hexmask.long.byte 0 0.--7. 1   "[7 : 0]    USERID                              = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00581384$ PER_TESLA9X45_Part5.per -queue SNOC_IPA_TFILT_ID_REVISIONID"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00581388
tree " SNOC_IPA_TFILT_MODE [RW]                                          0x00581388"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x00000001    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_IPA_TFILT_MODE PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   0.           "[ 0 ]      MODE                                = " "0x00 (?),0x01 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00581388$ PER_TESLA9X45_Part5.per -queue SNOC_IPA_TFILT_MODE"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0058138C
tree " SNOC_IPA_TFILT_ADDRBASE_LOW [RW]                                  0x0058138C"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0xFFFFFFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_IPA_TFILT_ADDRBASE_LOW PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.long 0 0.--31. 1  "[31 : 0]   ADDRBASE_LOW                        = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0058138C$ PER_TESLA9X45_Part5.per -queue SNOC_IPA_TFILT_ADDRBASE_LOW"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00581390
tree " SNOC_IPA_TFILT_ADDRBASE_HIGH [RW]                                 0x00581390"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x00000001    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_IPA_TFILT_ADDRBASE_HIGH PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   0.           "[ 0 ]      ADDRBASE_HIGH                       = " "0x00 (?),0x01 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00581390$ PER_TESLA9X45_Part5.per -queue SNOC_IPA_TFILT_ADDRBASE_HIGH"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00581394
tree " SNOC_IPA_TFILT_ADDRWINDOWSIZE [RW]                                0x00581394"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x0000003F    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_IPA_TFILT_ADDRWINDOWSIZE PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   0.--5.       "[5 : 0]    ADDRWINDOWSIZE                      = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?),0x08 (?),0x09 (?),0x0A (?),0x0B (?),0x0C (?),0x0D (?),0x0E (?),0x0F (?),0x10 (?),0x11 (?),0x12 (?),0x13 (?),0x14 (?),0x15 (?),0x16 (?),0x17 (?),0x18 (?),0x19 (?),0x1A (?),0x1B (?),0x1C (?),0x1D (?),0x1E (?),0x1F (?),0x20 (?),0x21 (?),0x22 (?),0x23 (?),0x24 (?),0x25 (?),0x26 (?),0x27 (?),0x28 (?),0x29 (?),0x2A (?),0x2B (?),0x2C (?),0x2D (?),0x2E (?),0x2F (?),0x30 (?),0x31 (?),0x32 (?),0x33 (?),0x34 (?),0x35 (?),0x36 (?),0x37 (?),0x38 (?),0x39 (?),0x3A (?),0x3B (?),0x3C (?),0x3D (?),0x3E (?),0x3F (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00581394$ PER_TESLA9X45_Part5.per -queue SNOC_IPA_TFILT_ADDRWINDOWSIZE"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00581398
tree " SNOC_IPA_TFILT_SRCIDBASE [RW]                                     0x00581398"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x00007FFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_IPA_TFILT_SRCIDBASE PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.word 0 0.--14. 1  "[14 : 0]   SRCIDBASE                           = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00581398$ PER_TESLA9X45_Part5.per -queue SNOC_IPA_TFILT_SRCIDBASE"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0058139C
tree " SNOC_IPA_TFILT_SRCIDMASK [RW]                                     0x0058139C"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x00007FFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_IPA_TFILT_SRCIDMASK PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.word 0 0.--14. 1  "[14 : 0]   SRCIDMASK                           = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0058139C$ PER_TESLA9X45_Part5.per -queue SNOC_IPA_TFILT_SRCIDMASK"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x005813A0
tree " SNOC_IPA_TFILT_OPCODE [RW]                                        0x005813A0"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x00000003    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_IPA_TFILT_OPCODE PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   1.           "[ 1 ]      WREN                                = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   0.           "[ 0 ]      RDEN                                = " "0x00 (?),0x01 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x005813A0$ PER_TESLA9X45_Part5.per -queue SNOC_IPA_TFILT_OPCODE"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x005813A4
tree " SNOC_IPA_TFILT_USERBASE [RW]                                      0x005813A4"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x0000FFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_IPA_TFILT_USERBASE PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.word 0 0.--15. 1  "[15 : 0]   USERBASE                            = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x005813A4$ PER_TESLA9X45_Part5.per -queue SNOC_IPA_TFILT_USERBASE"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x005813A8
tree " SNOC_IPA_TFILT_USERMASK [RW]                                      0x005813A8"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x0000FFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_IPA_TFILT_USERMASK PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.word 0 0.--15. 1  "[15 : 0]   USERMASK                            = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x005813A8$ PER_TESLA9X45_Part5.per -queue SNOC_IPA_TFILT_USERMASK"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00581400
tree " SNOC_QDSS_ETR_TFILT_ID_COREID [R]                                 0x00581400"
  group.long 0x0--0x3
   textline "POR 0xF440C909    MASK = 0xFFFFFFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_QDSS_ETR_TFILT_ID_COREID PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.long 0 8.--31. 1  "[31 : 8]   CORECHECKSUM                        = "
   textline ""
   hexmask.long.byte 0 0.--7. 1   "[7 : 0]    CORETYPEID                          = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00581400$ PER_TESLA9X45_Part5.per -queue SNOC_QDSS_ETR_TFILT_ID_COREID"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00581404
tree " SNOC_QDSS_ETR_TFILT_ID_REVISIONID [R]                             0x00581404"
  group.long 0x0--0x3
   textline "POR 0x00049C00    MASK = 0xFFFFFFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_QDSS_ETR_TFILT_ID_REVISIONID PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.long 0 8.--31. 1  "[31 : 8]   FLEXNOCID                           = "
   textline ""
   hexmask.long.byte 0 0.--7. 1   "[7 : 0]    USERID                              = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00581404$ PER_TESLA9X45_Part5.per -queue SNOC_QDSS_ETR_TFILT_ID_REVISIONID"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00581408
tree " SNOC_QDSS_ETR_TFILT_MODE [RW]                                     0x00581408"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x00000001    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_QDSS_ETR_TFILT_MODE PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   0.           "[ 0 ]      MODE                                = " "0x00 (?),0x01 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00581408$ PER_TESLA9X45_Part5.per -queue SNOC_QDSS_ETR_TFILT_MODE"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0058140C
tree " SNOC_QDSS_ETR_TFILT_ADDRBASE_LOW [RW]                             0x0058140C"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0xFFFFFFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_QDSS_ETR_TFILT_ADDRBASE_LOW PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.long 0 0.--31. 1  "[31 : 0]   ADDRBASE_LOW                        = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0058140C$ PER_TESLA9X45_Part5.per -queue SNOC_QDSS_ETR_TFILT_ADDRBASE_LOW"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00581414
tree " SNOC_QDSS_ETR_TFILT_ADDRWINDOWSIZE [RW]                           0x00581414"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x0000003F    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_QDSS_ETR_TFILT_ADDRWINDOWSIZE PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   0.--5.       "[5 : 0]    ADDRWINDOWSIZE                      = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?),0x08 (?),0x09 (?),0x0A (?),0x0B (?),0x0C (?),0x0D (?),0x0E (?),0x0F (?),0x10 (?),0x11 (?),0x12 (?),0x13 (?),0x14 (?),0x15 (?),0x16 (?),0x17 (?),0x18 (?),0x19 (?),0x1A (?),0x1B (?),0x1C (?),0x1D (?),0x1E (?),0x1F (?),0x20 (?),0x21 (?),0x22 (?),0x23 (?),0x24 (?),0x25 (?),0x26 (?),0x27 (?),0x28 (?),0x29 (?),0x2A (?),0x2B (?),0x2C (?),0x2D (?),0x2E (?),0x2F (?),0x30 (?),0x31 (?),0x32 (?),0x33 (?),0x34 (?),0x35 (?),0x36 (?),0x37 (?),0x38 (?),0x39 (?),0x3A (?),0x3B (?),0x3C (?),0x3D (?),0x3E (?),0x3F (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00581414$ PER_TESLA9X45_Part5.per -queue SNOC_QDSS_ETR_TFILT_ADDRWINDOWSIZE"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00581418
tree " SNOC_QDSS_ETR_TFILT_SRCIDBASE [RW]                                0x00581418"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x00007FFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_QDSS_ETR_TFILT_SRCIDBASE PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.word 0 0.--14. 1  "[14 : 0]   SRCIDBASE                           = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00581418$ PER_TESLA9X45_Part5.per -queue SNOC_QDSS_ETR_TFILT_SRCIDBASE"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0058141C
tree " SNOC_QDSS_ETR_TFILT_SRCIDMASK [RW]                                0x0058141C"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x00007FFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_QDSS_ETR_TFILT_SRCIDMASK PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.word 0 0.--14. 1  "[14 : 0]   SRCIDMASK                           = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0058141C$ PER_TESLA9X45_Part5.per -queue SNOC_QDSS_ETR_TFILT_SRCIDMASK"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00581420
tree " SNOC_QDSS_ETR_TFILT_OPCODE [RW]                                   0x00581420"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x00000003    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_QDSS_ETR_TFILT_OPCODE PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   1.           "[ 1 ]      WREN                                = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   0.           "[ 0 ]      RDEN                                = " "0x00 (?),0x01 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00581420$ PER_TESLA9X45_Part5.per -queue SNOC_QDSS_ETR_TFILT_OPCODE"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00581424
tree " SNOC_QDSS_ETR_TFILT_USERBASE [RW]                                 0x00581424"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x0000FFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_QDSS_ETR_TFILT_USERBASE PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.word 0 0.--15. 1  "[15 : 0]   USERBASE                            = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00581424$ PER_TESLA9X45_Part5.per -queue SNOC_QDSS_ETR_TFILT_USERBASE"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00581428
tree " SNOC_QDSS_ETR_TFILT_USERMASK [RW]                                 0x00581428"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x0000FFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_QDSS_ETR_TFILT_USERMASK PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.word 0 0.--15. 1  "[15 : 0]   USERMASK                            = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00581428$ PER_TESLA9X45_Part5.per -queue SNOC_QDSS_ETR_TFILT_USERMASK"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00582000
tree " SNOC_TPRB0_TPROF_ID_COREID [R]                                    0x00582000"
  group.long 0x0--0x3
   textline "POR 0xBEC2790A    MASK = 0xFFFFFFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_TPRB0_TPROF_ID_COREID PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.long 0 8.--31. 1  "[31 : 8]   CORECHECKSUM                        = "
   textline ""
   hexmask.long.byte 0 0.--7. 1   "[7 : 0]    CORETYPEID                          = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00582000$ PER_TESLA9X45_Part5.per -queue SNOC_TPRB0_TPROF_ID_COREID"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00582004
tree " SNOC_TPRB0_TPROF_ID_REVISIONID [R]                                0x00582004"
  group.long 0x0--0x3
   textline "POR 0x00049C00    MASK = 0xFFFFFFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_TPRB0_TPROF_ID_REVISIONID PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.long 0 8.--31. 1  "[31 : 8]   FLEXNOCID                           = "
   textline ""
   hexmask.long.byte 0 0.--7. 1   "[7 : 0]    USERID                              = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00582004$ PER_TESLA9X45_Part5.per -queue SNOC_TPRB0_TPROF_ID_REVISIONID"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00582008
tree " SNOC_TPRB0_TPROF_EN [RW]                                          0x00582008"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x00000001    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_TPRB0_TPROF_EN PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   0.           "[ 0 ]      EN                                  = " "0x00 (?),0x01 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00582008$ PER_TESLA9X45_Part5.per -queue SNOC_TPRB0_TPROF_EN"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0058200C
tree " SNOC_TPRB0_TPROF_MODE [RW]                                        0x0058200C"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x00000003    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_TPRB0_TPROF_MODE PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   0.--1.       "[1 : 0]    MODE                                = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0058200C$ PER_TESLA9X45_Part5.per -queue SNOC_TPRB0_TPROF_MODE"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00582010
tree " SNOC_TPRB0_TPROF_OBSERVEDSEL_0 [RW]                               0x00582010"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x00000001    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_TPRB0_TPROF_OBSERVEDSEL_0 PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   0.           "[ 0 ]      OBSERVEDSEL_0                       = " "0x00 (?),0x01 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00582010$ PER_TESLA9X45_Part5.per -queue SNOC_TPRB0_TPROF_OBSERVEDSEL_0"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00582014
tree " SNOC_TPRB0_TPROF_OBSERVEDSEL_1 [RW]                               0x00582014"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x00000001    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_TPRB0_TPROF_OBSERVEDSEL_1 PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   0.           "[ 0 ]      OBSERVEDSEL_1                       = " "0x00 (?),0x01 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00582014$ PER_TESLA9X45_Part5.per -queue SNOC_TPRB0_TPROF_OBSERVEDSEL_1"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00582020
tree " SNOC_TPRB0_TPROF_NTENURELINES_0 [RW]                              0x00582020"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x0000000F    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_TPRB0_TPROF_NTENURELINES_0 PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   0.--3.       "[3 : 0]    NTENURELINES_0                      = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?),0x08 (?),0x09 (?),0x0A (?),0x0B (?),0x0C (?),0x0D (?),0x0E (?),0x0F (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00582020$ PER_TESLA9X45_Part5.per -queue SNOC_TPRB0_TPROF_NTENURELINES_0"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0058202C
tree " SNOC_TPRB0_TPROF_THRESHOLDS_0_0 [RW]                              0x0058202C"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x0000000F    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_TPRB0_TPROF_THRESHOLDS_0_0 PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   0.--3.       "[3 : 0]    THRESHOLDS_0_0                      = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?),0x08 (?),0x09 (?),0x0A (?),0x0B (?),0x0C (?),0x0D (?),0x0E (?),0x0F (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0058202C$ PER_TESLA9X45_Part5.per -queue SNOC_TPRB0_TPROF_THRESHOLDS_0_0"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00582030
tree " SNOC_TPRB0_TPROF_THRESHOLDS_0_1 [RW]                              0x00582030"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x0000000F    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_TPRB0_TPROF_THRESHOLDS_0_1 PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   0.--3.       "[3 : 0]    THRESHOLDS_0_1                      = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?),0x08 (?),0x09 (?),0x0A (?),0x0B (?),0x0C (?),0x0D (?),0x0E (?),0x0F (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00582030$ PER_TESLA9X45_Part5.per -queue SNOC_TPRB0_TPROF_THRESHOLDS_0_1"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00582034
tree " SNOC_TPRB0_TPROF_THRESHOLDS_0_2 [RW]                              0x00582034"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x0000000F    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_TPRB0_TPROF_THRESHOLDS_0_2 PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   0.--3.       "[3 : 0]    THRESHOLDS_0_2                      = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?),0x08 (?),0x09 (?),0x0A (?),0x0B (?),0x0C (?),0x0D (?),0x0E (?),0x0F (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00582034$ PER_TESLA9X45_Part5.per -queue SNOC_TPRB0_TPROF_THRESHOLDS_0_2"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0058203C
tree " SNOC_TPRB0_TPROF_THRESHOLDS_1_0 [RW]                              0x0058203C"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x0000000F    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_TPRB0_TPROF_THRESHOLDS_1_0 PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   0.--3.       "[3 : 0]    THRESHOLDS_1_0                      = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?),0x08 (?),0x09 (?),0x0A (?),0x0B (?),0x0C (?),0x0D (?),0x0E (?),0x0F (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0058203C$ PER_TESLA9X45_Part5.per -queue SNOC_TPRB0_TPROF_THRESHOLDS_1_0"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00582040
tree " SNOC_TPRB0_TPROF_THRESHOLDS_1_1 [RW]                              0x00582040"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x0000000F    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_TPRB0_TPROF_THRESHOLDS_1_1 PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   0.--3.       "[3 : 0]    THRESHOLDS_1_1                      = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?),0x08 (?),0x09 (?),0x0A (?),0x0B (?),0x0C (?),0x0D (?),0x0E (?),0x0F (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00582040$ PER_TESLA9X45_Part5.per -queue SNOC_TPRB0_TPROF_THRESHOLDS_1_1"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00582044
tree " SNOC_TPRB0_TPROF_THRESHOLDS_1_2 [RW]                              0x00582044"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x0000000F    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_TPRB0_TPROF_THRESHOLDS_1_2 PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   0.--3.       "[3 : 0]    THRESHOLDS_1_2                      = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?),0x08 (?),0x09 (?),0x0A (?),0x0B (?),0x0C (?),0x0D (?),0x0E (?),0x0F (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00582044$ PER_TESLA9X45_Part5.per -queue SNOC_TPRB0_TPROF_THRESHOLDS_1_2"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0058206C
tree " SNOC_TPRB0_TPROF_OVERFLOWSTATUS [R]                               0x0058206C"
  group.long 0x0--0x3
   textline "POR 0xDEADBEEF [0xxxxxxxxx]    MASK =  "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_TPRB0_TPROF_OVERFLOWSTATUS PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   0.--1.       "[1 : 0]    OVERFLOWSTATUS                      = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0058206C$ PER_TESLA9X45_Part5.per -queue SNOC_TPRB0_TPROF_OVERFLOWSTATUS"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00582070
tree " SNOC_TPRB0_TPROF_OVERFLOWRESET [RW]                               0x00582070"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x00000003    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_TPRB0_TPROF_OVERFLOWRESET PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   0.--1.       "[1 : 0]    OVERFLOWRESET                       = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00582070$ PER_TESLA9X45_Part5.per -queue SNOC_TPRB0_TPROF_OVERFLOWRESET"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00582074
tree " SNOC_TPRB0_TPROF_PENDINGEVENTMODE [RW]                            0x00582074"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x00000001    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_TPRB0_TPROF_PENDINGEVENTMODE PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   0.           "[ 0 ]      PENDINGEVENTMODE                    = " "0x00 (?),0x01 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00582074$ PER_TESLA9X45_Part5.per -queue SNOC_TPRB0_TPROF_PENDINGEVENTMODE"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00582078
tree " SNOC_TPRB0_TPROF_PRESCALER [RW]                                   0x00582078"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x000000FF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_TPRB0_TPROF_PRESCALER PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.byte 0 0.--7. 1   "[7 : 0]    PRESCALER                           = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00582078$ PER_TESLA9X45_Part5.per -queue SNOC_TPRB0_TPROF_PRESCALER"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00582080
tree " SNOC_TPRB1_TPROF_ID_COREID [R]                                    0x00582080"
  group.long 0x0--0x3
   textline "POR 0x9E60DB0A    MASK = 0xFFFFFFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_TPRB1_TPROF_ID_COREID PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.long 0 8.--31. 1  "[31 : 8]   CORECHECKSUM                        = "
   textline ""
   hexmask.long.byte 0 0.--7. 1   "[7 : 0]    CORETYPEID                          = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00582080$ PER_TESLA9X45_Part5.per -queue SNOC_TPRB1_TPROF_ID_COREID"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00582084
tree " SNOC_TPRB1_TPROF_ID_REVISIONID [R]                                0x00582084"
  group.long 0x0--0x3
   textline "POR 0x00049C00    MASK = 0xFFFFFFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_TPRB1_TPROF_ID_REVISIONID PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.long 0 8.--31. 1  "[31 : 8]   FLEXNOCID                           = "
   textline ""
   hexmask.long.byte 0 0.--7. 1   "[7 : 0]    USERID                              = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00582084$ PER_TESLA9X45_Part5.per -queue SNOC_TPRB1_TPROF_ID_REVISIONID"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00582088
tree " SNOC_TPRB1_TPROF_EN [RW]                                          0x00582088"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x00000001    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_TPRB1_TPROF_EN PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   0.           "[ 0 ]      EN                                  = " "0x00 (?),0x01 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00582088$ PER_TESLA9X45_Part5.per -queue SNOC_TPRB1_TPROF_EN"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0058208C
tree " SNOC_TPRB1_TPROF_MODE [RW]                                        0x0058208C"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x00000003    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_TPRB1_TPROF_MODE PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   0.--1.       "[1 : 0]    MODE                                = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0058208C$ PER_TESLA9X45_Part5.per -queue SNOC_TPRB1_TPROF_MODE"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00582090
tree " SNOC_TPRB1_TPROF_OBSERVEDSEL_0 [RW]                               0x00582090"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x00000003    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_TPRB1_TPROF_OBSERVEDSEL_0 PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   0.--1.       "[1 : 0]    OBSERVEDSEL_0                       = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00582090$ PER_TESLA9X45_Part5.per -queue SNOC_TPRB1_TPROF_OBSERVEDSEL_0"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00582094
tree " SNOC_TPRB1_TPROF_OBSERVEDSEL_1 [RW]                               0x00582094"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x00000003    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_TPRB1_TPROF_OBSERVEDSEL_1 PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   0.--1.       "[1 : 0]    OBSERVEDSEL_1                       = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00582094$ PER_TESLA9X45_Part5.per -queue SNOC_TPRB1_TPROF_OBSERVEDSEL_1"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x005820A0
tree " SNOC_TPRB1_TPROF_NTENURELINES_0 [RW]                              0x005820A0"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x0000000F    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_TPRB1_TPROF_NTENURELINES_0 PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   0.--3.       "[3 : 0]    NTENURELINES_0                      = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?),0x08 (?),0x09 (?),0x0A (?),0x0B (?),0x0C (?),0x0D (?),0x0E (?),0x0F (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x005820A0$ PER_TESLA9X45_Part5.per -queue SNOC_TPRB1_TPROF_NTENURELINES_0"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x005820AC
tree " SNOC_TPRB1_TPROF_THRESHOLDS_0_0 [RW]                              0x005820AC"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x0000000F    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_TPRB1_TPROF_THRESHOLDS_0_0 PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   0.--3.       "[3 : 0]    THRESHOLDS_0_0                      = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?),0x08 (?),0x09 (?),0x0A (?),0x0B (?),0x0C (?),0x0D (?),0x0E (?),0x0F (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x005820AC$ PER_TESLA9X45_Part5.per -queue SNOC_TPRB1_TPROF_THRESHOLDS_0_0"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x005820B0
tree " SNOC_TPRB1_TPROF_THRESHOLDS_0_1 [RW]                              0x005820B0"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x0000000F    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_TPRB1_TPROF_THRESHOLDS_0_1 PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   0.--3.       "[3 : 0]    THRESHOLDS_0_1                      = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?),0x08 (?),0x09 (?),0x0A (?),0x0B (?),0x0C (?),0x0D (?),0x0E (?),0x0F (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x005820B0$ PER_TESLA9X45_Part5.per -queue SNOC_TPRB1_TPROF_THRESHOLDS_0_1"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x005820B4
tree " SNOC_TPRB1_TPROF_THRESHOLDS_0_2 [RW]                              0x005820B4"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x0000000F    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_TPRB1_TPROF_THRESHOLDS_0_2 PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   0.--3.       "[3 : 0]    THRESHOLDS_0_2                      = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?),0x08 (?),0x09 (?),0x0A (?),0x0B (?),0x0C (?),0x0D (?),0x0E (?),0x0F (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x005820B4$ PER_TESLA9X45_Part5.per -queue SNOC_TPRB1_TPROF_THRESHOLDS_0_2"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x005820BC
tree " SNOC_TPRB1_TPROF_THRESHOLDS_1_0 [RW]                              0x005820BC"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x0000000F    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_TPRB1_TPROF_THRESHOLDS_1_0 PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   0.--3.       "[3 : 0]    THRESHOLDS_1_0                      = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?),0x08 (?),0x09 (?),0x0A (?),0x0B (?),0x0C (?),0x0D (?),0x0E (?),0x0F (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x005820BC$ PER_TESLA9X45_Part5.per -queue SNOC_TPRB1_TPROF_THRESHOLDS_1_0"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x005820C0
tree " SNOC_TPRB1_TPROF_THRESHOLDS_1_1 [RW]                              0x005820C0"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x0000000F    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_TPRB1_TPROF_THRESHOLDS_1_1 PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   0.--3.       "[3 : 0]    THRESHOLDS_1_1                      = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?),0x08 (?),0x09 (?),0x0A (?),0x0B (?),0x0C (?),0x0D (?),0x0E (?),0x0F (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x005820C0$ PER_TESLA9X45_Part5.per -queue SNOC_TPRB1_TPROF_THRESHOLDS_1_1"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x005820C4
tree " SNOC_TPRB1_TPROF_THRESHOLDS_1_2 [RW]                              0x005820C4"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x0000000F    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_TPRB1_TPROF_THRESHOLDS_1_2 PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   0.--3.       "[3 : 0]    THRESHOLDS_1_2                      = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?),0x08 (?),0x09 (?),0x0A (?),0x0B (?),0x0C (?),0x0D (?),0x0E (?),0x0F (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x005820C4$ PER_TESLA9X45_Part5.per -queue SNOC_TPRB1_TPROF_THRESHOLDS_1_2"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x005820EC
tree " SNOC_TPRB1_TPROF_OVERFLOWSTATUS [R]                               0x005820EC"
  group.long 0x0--0x3
   textline "POR 0xDEADBEEF [0xxxxxxxxx]    MASK =  "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_TPRB1_TPROF_OVERFLOWSTATUS PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   0.--1.       "[1 : 0]    OVERFLOWSTATUS                      = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x005820EC$ PER_TESLA9X45_Part5.per -queue SNOC_TPRB1_TPROF_OVERFLOWSTATUS"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x005820F0
tree " SNOC_TPRB1_TPROF_OVERFLOWRESET [RW]                               0x005820F0"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x00000003    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_TPRB1_TPROF_OVERFLOWRESET PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   0.--1.       "[1 : 0]    OVERFLOWRESET                       = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x005820F0$ PER_TESLA9X45_Part5.per -queue SNOC_TPRB1_TPROF_OVERFLOWRESET"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x005820F4
tree " SNOC_TPRB1_TPROF_PENDINGEVENTMODE [RW]                            0x005820F4"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x00000001    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_TPRB1_TPROF_PENDINGEVENTMODE PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   0.           "[ 0 ]      PENDINGEVENTMODE                    = " "0x00 (?),0x01 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x005820F4$ PER_TESLA9X45_Part5.per -queue SNOC_TPRB1_TPROF_PENDINGEVENTMODE"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x005820F8
tree " SNOC_TPRB1_TPROF_PRESCALER [RW]                                   0x005820F8"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x000000FF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_TPRB1_TPROF_PRESCALER PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.byte 0 0.--7. 1   "[7 : 0]    PRESCALER                           = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x005820F8$ PER_TESLA9X45_Part5.per -queue SNOC_TPRB1_TPROF_PRESCALER"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00582100
tree " SNOC_TPRB2_TPROF_ID_COREID [R]                                    0x00582100"
  group.long 0x0--0x3
   textline "POR 0xE71C120A    MASK = 0xFFFFFFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_TPRB2_TPROF_ID_COREID PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.long 0 8.--31. 1  "[31 : 8]   CORECHECKSUM                        = "
   textline ""
   hexmask.long.byte 0 0.--7. 1   "[7 : 0]    CORETYPEID                          = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00582100$ PER_TESLA9X45_Part5.per -queue SNOC_TPRB2_TPROF_ID_COREID"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00582104
tree " SNOC_TPRB2_TPROF_ID_REVISIONID [R]                                0x00582104"
  group.long 0x0--0x3
   textline "POR 0x00049C00    MASK = 0xFFFFFFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_TPRB2_TPROF_ID_REVISIONID PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.long 0 8.--31. 1  "[31 : 8]   FLEXNOCID                           = "
   textline ""
   hexmask.long.byte 0 0.--7. 1   "[7 : 0]    USERID                              = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00582104$ PER_TESLA9X45_Part5.per -queue SNOC_TPRB2_TPROF_ID_REVISIONID"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00582108
tree " SNOC_TPRB2_TPROF_EN [RW]                                          0x00582108"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x00000001    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_TPRB2_TPROF_EN PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   0.           "[ 0 ]      EN                                  = " "0x00 (?),0x01 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00582108$ PER_TESLA9X45_Part5.per -queue SNOC_TPRB2_TPROF_EN"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0058210C
tree " SNOC_TPRB2_TPROF_MODE [RW]                                        0x0058210C"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x00000003    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_TPRB2_TPROF_MODE PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   0.--1.       "[1 : 0]    MODE                                = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0058210C$ PER_TESLA9X45_Part5.per -queue SNOC_TPRB2_TPROF_MODE"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00582110
tree " SNOC_TPRB2_TPROF_OBSERVEDSEL_0 [RW]                               0x00582110"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x00000003    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_TPRB2_TPROF_OBSERVEDSEL_0 PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   0.--1.       "[1 : 0]    OBSERVEDSEL_0                       = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00582110$ PER_TESLA9X45_Part5.per -queue SNOC_TPRB2_TPROF_OBSERVEDSEL_0"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00582114
tree " SNOC_TPRB2_TPROF_OBSERVEDSEL_1 [RW]                               0x00582114"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x00000003    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_TPRB2_TPROF_OBSERVEDSEL_1 PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   0.--1.       "[1 : 0]    OBSERVEDSEL_1                       = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00582114$ PER_TESLA9X45_Part5.per -queue SNOC_TPRB2_TPROF_OBSERVEDSEL_1"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00582120
tree " SNOC_TPRB2_TPROF_NTENURELINES_0 [RW]                              0x00582120"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x0000000F    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_TPRB2_TPROF_NTENURELINES_0 PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   0.--3.       "[3 : 0]    NTENURELINES_0                      = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?),0x08 (?),0x09 (?),0x0A (?),0x0B (?),0x0C (?),0x0D (?),0x0E (?),0x0F (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00582120$ PER_TESLA9X45_Part5.per -queue SNOC_TPRB2_TPROF_NTENURELINES_0"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0058212C
tree " SNOC_TPRB2_TPROF_THRESHOLDS_0_0 [RW]                              0x0058212C"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x0000000F    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_TPRB2_TPROF_THRESHOLDS_0_0 PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   0.--3.       "[3 : 0]    THRESHOLDS_0_0                      = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?),0x08 (?),0x09 (?),0x0A (?),0x0B (?),0x0C (?),0x0D (?),0x0E (?),0x0F (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0058212C$ PER_TESLA9X45_Part5.per -queue SNOC_TPRB2_TPROF_THRESHOLDS_0_0"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00582130
tree " SNOC_TPRB2_TPROF_THRESHOLDS_0_1 [RW]                              0x00582130"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x0000000F    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_TPRB2_TPROF_THRESHOLDS_0_1 PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   0.--3.       "[3 : 0]    THRESHOLDS_0_1                      = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?),0x08 (?),0x09 (?),0x0A (?),0x0B (?),0x0C (?),0x0D (?),0x0E (?),0x0F (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00582130$ PER_TESLA9X45_Part5.per -queue SNOC_TPRB2_TPROF_THRESHOLDS_0_1"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00582134
tree " SNOC_TPRB2_TPROF_THRESHOLDS_0_2 [RW]                              0x00582134"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x0000000F    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_TPRB2_TPROF_THRESHOLDS_0_2 PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   0.--3.       "[3 : 0]    THRESHOLDS_0_2                      = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?),0x08 (?),0x09 (?),0x0A (?),0x0B (?),0x0C (?),0x0D (?),0x0E (?),0x0F (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00582134$ PER_TESLA9X45_Part5.per -queue SNOC_TPRB2_TPROF_THRESHOLDS_0_2"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0058213C
tree " SNOC_TPRB2_TPROF_THRESHOLDS_1_0 [RW]                              0x0058213C"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x0000000F    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_TPRB2_TPROF_THRESHOLDS_1_0 PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   0.--3.       "[3 : 0]    THRESHOLDS_1_0                      = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?),0x08 (?),0x09 (?),0x0A (?),0x0B (?),0x0C (?),0x0D (?),0x0E (?),0x0F (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0058213C$ PER_TESLA9X45_Part5.per -queue SNOC_TPRB2_TPROF_THRESHOLDS_1_0"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00582140
tree " SNOC_TPRB2_TPROF_THRESHOLDS_1_1 [RW]                              0x00582140"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x0000000F    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_TPRB2_TPROF_THRESHOLDS_1_1 PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   0.--3.       "[3 : 0]    THRESHOLDS_1_1                      = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?),0x08 (?),0x09 (?),0x0A (?),0x0B (?),0x0C (?),0x0D (?),0x0E (?),0x0F (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00582140$ PER_TESLA9X45_Part5.per -queue SNOC_TPRB2_TPROF_THRESHOLDS_1_1"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00582144
tree " SNOC_TPRB2_TPROF_THRESHOLDS_1_2 [RW]                              0x00582144"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x0000000F    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_TPRB2_TPROF_THRESHOLDS_1_2 PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   0.--3.       "[3 : 0]    THRESHOLDS_1_2                      = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?),0x08 (?),0x09 (?),0x0A (?),0x0B (?),0x0C (?),0x0D (?),0x0E (?),0x0F (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00582144$ PER_TESLA9X45_Part5.per -queue SNOC_TPRB2_TPROF_THRESHOLDS_1_2"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0058216C
tree " SNOC_TPRB2_TPROF_OVERFLOWSTATUS [R]                               0x0058216C"
  group.long 0x0--0x3
   textline "POR 0xDEADBEEF [0xxxxxxxxx]    MASK =  "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_TPRB2_TPROF_OVERFLOWSTATUS PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   0.--1.       "[1 : 0]    OVERFLOWSTATUS                      = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0058216C$ PER_TESLA9X45_Part5.per -queue SNOC_TPRB2_TPROF_OVERFLOWSTATUS"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00582170
tree " SNOC_TPRB2_TPROF_OVERFLOWRESET [RW]                               0x00582170"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x00000003    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_TPRB2_TPROF_OVERFLOWRESET PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   0.--1.       "[1 : 0]    OVERFLOWRESET                       = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00582170$ PER_TESLA9X45_Part5.per -queue SNOC_TPRB2_TPROF_OVERFLOWRESET"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00582174
tree " SNOC_TPRB2_TPROF_PENDINGEVENTMODE [RW]                            0x00582174"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x00000001    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_TPRB2_TPROF_PENDINGEVENTMODE PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   0.           "[ 0 ]      PENDINGEVENTMODE                    = " "0x00 (?),0x01 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00582174$ PER_TESLA9X45_Part5.per -queue SNOC_TPRB2_TPROF_PENDINGEVENTMODE"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00582178
tree " SNOC_TPRB2_TPROF_PRESCALER [RW]                                   0x00582178"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x000000FF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_TPRB2_TPROF_PRESCALER PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.byte 0 0.--7. 1   "[7 : 0]    PRESCALER                           = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00582178$ PER_TESLA9X45_Part5.per -queue SNOC_TPRB2_TPROF_PRESCALER"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00583000
tree " SNOC_EPRB0_SPROF_ID_COREID [R]                                    0x00583000"
  group.long 0x0--0x3
   textline "POR 0x4B864B06    MASK = 0xFFFFFFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_EPRB0_SPROF_ID_COREID PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.long 0 8.--31. 1  "[31 : 8]   CORECHECKSUM                        = "
   textline ""
   hexmask.long.byte 0 0.--7. 1   "[7 : 0]    CORETYPEID                          = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00583000$ PER_TESLA9X45_Part5.per -queue SNOC_EPRB0_SPROF_ID_COREID"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00583004
tree " SNOC_EPRB0_SPROF_ID_REVISIONID [R]                                0x00583004"
  group.long 0x0--0x3
   textline "POR 0x00049C00    MASK = 0xFFFFFFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_EPRB0_SPROF_ID_REVISIONID PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.long 0 8.--31. 1  "[31 : 8]   FLEXNOCID                           = "
   textline ""
   hexmask.long.byte 0 0.--7. 1   "[7 : 0]    USERID                              = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00583004$ PER_TESLA9X45_Part5.per -queue SNOC_EPRB0_SPROF_ID_REVISIONID"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00583008
tree " SNOC_EPRB0_SPROF_MAINCTL [RW]                                     0x00583008"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x000000FF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_EPRB0_SPROF_MAINCTL PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   7.           "[ 7 ]      FILTBYTEALWAYSCHAINABLEEN           = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   6.           "[ 6 ]      INTRUSIVEMODE                       = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   5.           "[ 5 ]      STATCONDDUMP                        = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   4.           "[ 4 ]      ALARMEN                             = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   3.           "[ 3 ]      STATEN                              = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   2.           "[ 2 ]      PAYLOADEN                           = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   1.           "[ 1 ]      TRACEEN                             = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   0.           "[ 0 ]      ERREN                               = " "0x00 (?),0x01 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00583008$ PER_TESLA9X45_Part5.per -queue SNOC_EPRB0_SPROF_MAINCTL"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0058300C
tree " SNOC_EPRB0_SPROF_CFGCTL [RW]                                      0x0058300C"
  group.long 0x0--0x3
   textline "POR 0xDEADBEEF [0xxxxxxxxx]    MASK =  "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_EPRB0_SPROF_CFGCTL PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   1.           "[ 1 ]      ACTIVE                              = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   0.           "[ 0 ]      GLOBALEN                            = " "0x00 (?),0x01 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0058300C$ PER_TESLA9X45_Part5.per -queue SNOC_EPRB0_SPROF_CFGCTL"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00583010
tree " SNOC_EPRB0_SPROF_TRACEPORTSEL [RW]                                0x00583010"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = undef         "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_EPRB0_SPROF_TRACEPORTSEL PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   0.--1.       "[1 : 0]    TRACEPORTSEL                        = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00583010$ PER_TESLA9X45_Part5.per -queue SNOC_EPRB0_SPROF_TRACEPORTSEL"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00583014
tree " SNOC_EPRB0_SPROF_FILTERLUT [RW]                                   0x00583014"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x0000FFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_EPRB0_SPROF_FILTERLUT PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.word 0 0.--15. 1  "[15 : 0]   FILTERLUT                           = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00583014$ PER_TESLA9X45_Part5.per -queue SNOC_EPRB0_SPROF_FILTERLUT"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00583018
tree " SNOC_EPRB0_SPROF_TRACEALARMEN [RW]                                0x00583018"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x0000001F    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_EPRB0_SPROF_TRACEALARMEN PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   0.--4.       "[4 : 0]    TRACEALARMEN                        = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?),0x08 (?),0x09 (?),0x0A (?),0x0B (?),0x0C (?),0x0D (?),0x0E (?),0x0F (?),0x10 (?),0x11 (?),0x12 (?),0x13 (?),0x14 (?),0x15 (?),0x16 (?),0x17 (?),0x18 (?),0x19 (?),0x1A (?),0x1B (?),0x1C (?),0x1D (?),0x1E (?),0x1F (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00583018$ PER_TESLA9X45_Part5.per -queue SNOC_EPRB0_SPROF_TRACEALARMEN"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0058301C
tree " SNOC_EPRB0_SPROF_TRACEALARMSTATUS [R]                             0x0058301C"
  group.long 0x0--0x3
   textline "POR 0xDEADBEEF [0xxxxxxxxx]    MASK =  "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_EPRB0_SPROF_TRACEALARMSTATUS PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   0.--4.       "[4 : 0]    TRACEALARMSTATUS                    = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?),0x08 (?),0x09 (?),0x0A (?),0x0B (?),0x0C (?),0x0D (?),0x0E (?),0x0F (?),0x10 (?),0x11 (?),0x12 (?),0x13 (?),0x14 (?),0x15 (?),0x16 (?),0x17 (?),0x18 (?),0x19 (?),0x1A (?),0x1B (?),0x1C (?),0x1D (?),0x1E (?),0x1F (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0058301C$ PER_TESLA9X45_Part5.per -queue SNOC_EPRB0_SPROF_TRACEALARMSTATUS"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00583020
tree " SNOC_EPRB0_SPROF_TRACEALARMCLR [RW]                               0x00583020"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x0000001F    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_EPRB0_SPROF_TRACEALARMCLR PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   0.--4.       "[4 : 0]    TRACEALARMCLR                       = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?),0x08 (?),0x09 (?),0x0A (?),0x0B (?),0x0C (?),0x0D (?),0x0E (?),0x0F (?),0x10 (?),0x11 (?),0x12 (?),0x13 (?),0x14 (?),0x15 (?),0x16 (?),0x17 (?),0x18 (?),0x19 (?),0x1A (?),0x1B (?),0x1C (?),0x1D (?),0x1E (?),0x1F (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00583020$ PER_TESLA9X45_Part5.per -queue SNOC_EPRB0_SPROF_TRACEALARMCLR"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00583024
tree " SNOC_EPRB0_SPROF_STATPERIOD [RW]                                  0x00583024"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x0000001F    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_EPRB0_SPROF_STATPERIOD PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   0.--4.       "[4 : 0]    STATPERIOD                          = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?),0x08 (?),0x09 (?),0x0A (?),0x0B (?),0x0C (?),0x0D (?),0x0E (?),0x0F (?),0x10 (?),0x11 (?),0x12 (?),0x13 (?),0x14 (?),0x15 (?),0x16 (?),0x17 (?),0x18 (?),0x19 (?),0x1A (?),0x1B (?),0x1C (?),0x1D (?),0x1E (?),0x1F (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00583024$ PER_TESLA9X45_Part5.per -queue SNOC_EPRB0_SPROF_STATPERIOD"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00583028
tree " SNOC_EPRB0_SPROF_STATGO [RW]                                      0x00583028"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x00000001    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_EPRB0_SPROF_STATGO PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   0.           "[ 0 ]      STATGO                              = " "0x00 (?),0x01 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00583028$ PER_TESLA9X45_Part5.per -queue SNOC_EPRB0_SPROF_STATGO"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0058302C
tree " SNOC_EPRB0_SPROF_STATALARMMIN [RW]                                0x0058302C"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0xFFFFFFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_EPRB0_SPROF_STATALARMMIN PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.long 0 0.--31. 1  "[31 : 0]   STATALARMMIN                        = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0058302C$ PER_TESLA9X45_Part5.per -queue SNOC_EPRB0_SPROF_STATALARMMIN"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00583030
tree " SNOC_EPRB0_SPROF_STATALARMMAX [RW]                                0x00583030"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0xFFFFFFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_EPRB0_SPROF_STATALARMMAX PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.long 0 0.--31. 1  "[31 : 0]   STATALARMMAX                        = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00583030$ PER_TESLA9X45_Part5.per -queue SNOC_EPRB0_SPROF_STATALARMMAX"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00583034
tree " SNOC_EPRB0_SPROF_STATALARMSTATUS [R]                              0x00583034"
  group.long 0x0--0x3
   textline "POR 0xDEADBEEF [0xxxxxxxxx]    MASK =  "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_EPRB0_SPROF_STATALARMSTATUS PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   0.           "[ 0 ]      STATALARMSTATUS                     = " "0x00 (?),0x01 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00583034$ PER_TESLA9X45_Part5.per -queue SNOC_EPRB0_SPROF_STATALARMSTATUS"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00583038
tree " SNOC_EPRB0_SPROF_STATALARMCLR [RW]                                0x00583038"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x00000001    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_EPRB0_SPROF_STATALARMCLR PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   0.           "[ 0 ]      STATALARMCLR                        = " "0x00 (?),0x01 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00583038$ PER_TESLA9X45_Part5.per -queue SNOC_EPRB0_SPROF_STATALARMCLR"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00583044
tree " SNOC_EPRB0_SPROF_FILTERS_0_ROUTEIDBASE [RW]                       0x00583044"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x1FFFFFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_EPRB0_SPROF_FILTERS_0_ROUTEIDBASE PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.long 0 0.--28. 1  "[28 : 0]   FILTERS_0_ROUTEIDBASE               = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00583044$ PER_TESLA9X45_Part5.per -queue SNOC_EPRB0_SPROF_FILTERS_0_ROUTEIDBASE"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00583048
tree " SNOC_EPRB0_SPROF_FILTERS_0_ROUTEIDMASK [RW]                       0x00583048"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x1FFFFFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_EPRB0_SPROF_FILTERS_0_ROUTEIDMASK PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.long 0 0.--28. 1  "[28 : 0]   FILTERS_0_ROUTEIDMASK               = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00583048$ PER_TESLA9X45_Part5.per -queue SNOC_EPRB0_SPROF_FILTERS_0_ROUTEIDMASK"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0058304C
tree " SNOC_EPRB0_SPROF_FILTERS_0_ADDRBASE_LOW [RW]                      0x0058304C"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0xFFFFFFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_EPRB0_SPROF_FILTERS_0_ADDRBASE_LOW PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.long 0 0.--31. 1  "[31 : 0]   FILTERS_0_ADDRBASE_LOW              = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0058304C$ PER_TESLA9X45_Part5.per -queue SNOC_EPRB0_SPROF_FILTERS_0_ADDRBASE_LOW"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00583050
tree " SNOC_EPRB0_SPROF_FILTERS_0_ADDRBASE_HIGH [RW]                     0x00583050"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x00000001    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_EPRB0_SPROF_FILTERS_0_ADDRBASE_HIGH PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   0.           "[ 0 ]      FILTERS_0_ADDRBASE_HIGH             = " "0x00 (?),0x01 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00583050$ PER_TESLA9X45_Part5.per -queue SNOC_EPRB0_SPROF_FILTERS_0_ADDRBASE_HIGH"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00583054
tree " SNOC_EPRB0_SPROF_FILTERS_0_WINDOWSIZE [RW]                        0x00583054"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x0000003F    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_EPRB0_SPROF_FILTERS_0_WINDOWSIZE PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   0.--5.       "[5 : 0]    FILTERS_0_WINDOWSIZE                = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?),0x08 (?),0x09 (?),0x0A (?),0x0B (?),0x0C (?),0x0D (?),0x0E (?),0x0F (?),0x10 (?),0x11 (?),0x12 (?),0x13 (?),0x14 (?),0x15 (?),0x16 (?),0x17 (?),0x18 (?),0x19 (?),0x1A (?),0x1B (?),0x1C (?),0x1D (?),0x1E (?),0x1F (?),0x20 (?),0x21 (?),0x22 (?),0x23 (?),0x24 (?),0x25 (?),0x26 (?),0x27 (?),0x28 (?),0x29 (?),0x2A (?),0x2B (?),0x2C (?),0x2D (?),0x2E (?),0x2F (?),0x30 (?),0x31 (?),0x32 (?),0x33 (?),0x34 (?),0x35 (?),0x36 (?),0x37 (?),0x38 (?),0x39 (?),0x3A (?),0x3B (?),0x3C (?),0x3D (?),0x3E (?),0x3F (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00583054$ PER_TESLA9X45_Part5.per -queue SNOC_EPRB0_SPROF_FILTERS_0_WINDOWSIZE"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00583060
tree " SNOC_EPRB0_SPROF_FILTERS_0_OPCODE [RW]                            0x00583060"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x0000000F    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_EPRB0_SPROF_FILTERS_0_OPCODE PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   3.           "[ 3 ]      URGEN                               = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   2.           "[ 2 ]      LOCKEN                              = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   1.           "[ 1 ]      WREN                                = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   0.           "[ 0 ]      RDEN                                = " "0x00 (?),0x01 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00583060$ PER_TESLA9X45_Part5.per -queue SNOC_EPRB0_SPROF_FILTERS_0_OPCODE"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00583064
tree " SNOC_EPRB0_SPROF_FILTERS_0_STATUS [RW]                            0x00583064"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x00000003    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_EPRB0_SPROF_FILTERS_0_STATUS PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   1.           "[ 1 ]      RSPEN                               = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   0.           "[ 0 ]      REQEN                               = " "0x00 (?),0x01 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00583064$ PER_TESLA9X45_Part5.per -queue SNOC_EPRB0_SPROF_FILTERS_0_STATUS"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00583068
tree " SNOC_EPRB0_SPROF_FILTERS_0_LENGTH [RW]                            0x00583068"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x0000000F    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_EPRB0_SPROF_FILTERS_0_LENGTH PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   0.--3.       "[3 : 0]    FILTERS_0_LENGTH                    = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?),0x08 (?),0x09 (?),0x0A (?),0x0B (?),0x0C (?),0x0D (?),0x0E (?),0x0F (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00583068$ PER_TESLA9X45_Part5.per -queue SNOC_EPRB0_SPROF_FILTERS_0_LENGTH"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0058306C
tree " SNOC_EPRB0_SPROF_FILTERS_0_URGENCY [RW]                           0x0058306C"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x00000003    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_EPRB0_SPROF_FILTERS_0_URGENCY PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   0.--1.       "[1 : 0]    FILTERS_0_URGENCY                   = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0058306C$ PER_TESLA9X45_Part5.per -queue SNOC_EPRB0_SPROF_FILTERS_0_URGENCY"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00583080
tree " SNOC_EPRB0_SPROF_FILTERS_1_ROUTEIDBASE [RW]                       0x00583080"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x1FFFFFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_EPRB0_SPROF_FILTERS_1_ROUTEIDBASE PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.long 0 0.--28. 1  "[28 : 0]   FILTERS_1_ROUTEIDBASE               = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00583080$ PER_TESLA9X45_Part5.per -queue SNOC_EPRB0_SPROF_FILTERS_1_ROUTEIDBASE"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00583084
tree " SNOC_EPRB0_SPROF_FILTERS_1_ROUTEIDMASK [RW]                       0x00583084"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x1FFFFFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_EPRB0_SPROF_FILTERS_1_ROUTEIDMASK PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.long 0 0.--28. 1  "[28 : 0]   FILTERS_1_ROUTEIDMASK               = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00583084$ PER_TESLA9X45_Part5.per -queue SNOC_EPRB0_SPROF_FILTERS_1_ROUTEIDMASK"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00583088
tree " SNOC_EPRB0_SPROF_FILTERS_1_ADDRBASE_LOW [RW]                      0x00583088"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0xFFFFFFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_EPRB0_SPROF_FILTERS_1_ADDRBASE_LOW PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.long 0 0.--31. 1  "[31 : 0]   FILTERS_1_ADDRBASE_LOW              = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00583088$ PER_TESLA9X45_Part5.per -queue SNOC_EPRB0_SPROF_FILTERS_1_ADDRBASE_LOW"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0058308C
tree " SNOC_EPRB0_SPROF_FILTERS_1_ADDRBASE_HIGH [RW]                     0x0058308C"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x00000001    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_EPRB0_SPROF_FILTERS_1_ADDRBASE_HIGH PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   0.           "[ 0 ]      FILTERS_1_ADDRBASE_HIGH             = " "0x00 (?),0x01 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0058308C$ PER_TESLA9X45_Part5.per -queue SNOC_EPRB0_SPROF_FILTERS_1_ADDRBASE_HIGH"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00583090
tree " SNOC_EPRB0_SPROF_FILTERS_1_WINDOWSIZE [RW]                        0x00583090"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x0000003F    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_EPRB0_SPROF_FILTERS_1_WINDOWSIZE PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   0.--5.       "[5 : 0]    FILTERS_1_WINDOWSIZE                = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?),0x08 (?),0x09 (?),0x0A (?),0x0B (?),0x0C (?),0x0D (?),0x0E (?),0x0F (?),0x10 (?),0x11 (?),0x12 (?),0x13 (?),0x14 (?),0x15 (?),0x16 (?),0x17 (?),0x18 (?),0x19 (?),0x1A (?),0x1B (?),0x1C (?),0x1D (?),0x1E (?),0x1F (?),0x20 (?),0x21 (?),0x22 (?),0x23 (?),0x24 (?),0x25 (?),0x26 (?),0x27 (?),0x28 (?),0x29 (?),0x2A (?),0x2B (?),0x2C (?),0x2D (?),0x2E (?),0x2F (?),0x30 (?),0x31 (?),0x32 (?),0x33 (?),0x34 (?),0x35 (?),0x36 (?),0x37 (?),0x38 (?),0x39 (?),0x3A (?),0x3B (?),0x3C (?),0x3D (?),0x3E (?),0x3F (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00583090$ PER_TESLA9X45_Part5.per -queue SNOC_EPRB0_SPROF_FILTERS_1_WINDOWSIZE"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0058309C
tree " SNOC_EPRB0_SPROF_FILTERS_1_OPCODE [RW]                            0x0058309C"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x0000000F    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_EPRB0_SPROF_FILTERS_1_OPCODE PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   3.           "[ 3 ]      URGEN                               = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   2.           "[ 2 ]      LOCKEN                              = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   1.           "[ 1 ]      WREN                                = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   0.           "[ 0 ]      RDEN                                = " "0x00 (?),0x01 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0058309C$ PER_TESLA9X45_Part5.per -queue SNOC_EPRB0_SPROF_FILTERS_1_OPCODE"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x005830A0
tree " SNOC_EPRB0_SPROF_FILTERS_1_STATUS [RW]                            0x005830A0"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x00000003    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_EPRB0_SPROF_FILTERS_1_STATUS PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   1.           "[ 1 ]      RSPEN                               = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   0.           "[ 0 ]      REQEN                               = " "0x00 (?),0x01 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x005830A0$ PER_TESLA9X45_Part5.per -queue SNOC_EPRB0_SPROF_FILTERS_1_STATUS"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x005830A4
tree " SNOC_EPRB0_SPROF_FILTERS_1_LENGTH [RW]                            0x005830A4"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x0000000F    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_EPRB0_SPROF_FILTERS_1_LENGTH PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   0.--3.       "[3 : 0]    FILTERS_1_LENGTH                    = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?),0x08 (?),0x09 (?),0x0A (?),0x0B (?),0x0C (?),0x0D (?),0x0E (?),0x0F (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x005830A4$ PER_TESLA9X45_Part5.per -queue SNOC_EPRB0_SPROF_FILTERS_1_LENGTH"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x005830A8
tree " SNOC_EPRB0_SPROF_FILTERS_1_URGENCY [RW]                           0x005830A8"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x00000003    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_EPRB0_SPROF_FILTERS_1_URGENCY PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   0.--1.       "[1 : 0]    FILTERS_1_URGENCY                   = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x005830A8$ PER_TESLA9X45_Part5.per -queue SNOC_EPRB0_SPROF_FILTERS_1_URGENCY"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x005830BC
tree " SNOC_EPRB0_SPROF_FILTERS_2_ROUTEIDBASE [RW]                       0x005830BC"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x1FFFFFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_EPRB0_SPROF_FILTERS_2_ROUTEIDBASE PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.long 0 0.--28. 1  "[28 : 0]   FILTERS_2_ROUTEIDBASE               = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x005830BC$ PER_TESLA9X45_Part5.per -queue SNOC_EPRB0_SPROF_FILTERS_2_ROUTEIDBASE"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x005830C0
tree " SNOC_EPRB0_SPROF_FILTERS_2_ROUTEIDMASK [RW]                       0x005830C0"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x1FFFFFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_EPRB0_SPROF_FILTERS_2_ROUTEIDMASK PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.long 0 0.--28. 1  "[28 : 0]   FILTERS_2_ROUTEIDMASK               = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x005830C0$ PER_TESLA9X45_Part5.per -queue SNOC_EPRB0_SPROF_FILTERS_2_ROUTEIDMASK"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x005830C4
tree " SNOC_EPRB0_SPROF_FILTERS_2_ADDRBASE_LOW [RW]                      0x005830C4"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0xFFFFFFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_EPRB0_SPROF_FILTERS_2_ADDRBASE_LOW PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.long 0 0.--31. 1  "[31 : 0]   FILTERS_2_ADDRBASE_LOW              = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x005830C4$ PER_TESLA9X45_Part5.per -queue SNOC_EPRB0_SPROF_FILTERS_2_ADDRBASE_LOW"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x005830C8
tree " SNOC_EPRB0_SPROF_FILTERS_2_ADDRBASE_HIGH [RW]                     0x005830C8"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x00000001    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_EPRB0_SPROF_FILTERS_2_ADDRBASE_HIGH PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   0.           "[ 0 ]      FILTERS_2_ADDRBASE_HIGH             = " "0x00 (?),0x01 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x005830C8$ PER_TESLA9X45_Part5.per -queue SNOC_EPRB0_SPROF_FILTERS_2_ADDRBASE_HIGH"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x005830CC
tree " SNOC_EPRB0_SPROF_FILTERS_2_WINDOWSIZE [RW]                        0x005830CC"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x0000003F    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_EPRB0_SPROF_FILTERS_2_WINDOWSIZE PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   0.--5.       "[5 : 0]    FILTERS_2_WINDOWSIZE                = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?),0x08 (?),0x09 (?),0x0A (?),0x0B (?),0x0C (?),0x0D (?),0x0E (?),0x0F (?),0x10 (?),0x11 (?),0x12 (?),0x13 (?),0x14 (?),0x15 (?),0x16 (?),0x17 (?),0x18 (?),0x19 (?),0x1A (?),0x1B (?),0x1C (?),0x1D (?),0x1E (?),0x1F (?),0x20 (?),0x21 (?),0x22 (?),0x23 (?),0x24 (?),0x25 (?),0x26 (?),0x27 (?),0x28 (?),0x29 (?),0x2A (?),0x2B (?),0x2C (?),0x2D (?),0x2E (?),0x2F (?),0x30 (?),0x31 (?),0x32 (?),0x33 (?),0x34 (?),0x35 (?),0x36 (?),0x37 (?),0x38 (?),0x39 (?),0x3A (?),0x3B (?),0x3C (?),0x3D (?),0x3E (?),0x3F (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x005830CC$ PER_TESLA9X45_Part5.per -queue SNOC_EPRB0_SPROF_FILTERS_2_WINDOWSIZE"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x005830D8
tree " SNOC_EPRB0_SPROF_FILTERS_2_OPCODE [RW]                            0x005830D8"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x0000000F    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_EPRB0_SPROF_FILTERS_2_OPCODE PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   3.           "[ 3 ]      URGEN                               = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   2.           "[ 2 ]      LOCKEN                              = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   1.           "[ 1 ]      WREN                                = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   0.           "[ 0 ]      RDEN                                = " "0x00 (?),0x01 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x005830D8$ PER_TESLA9X45_Part5.per -queue SNOC_EPRB0_SPROF_FILTERS_2_OPCODE"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x005830DC
tree " SNOC_EPRB0_SPROF_FILTERS_2_STATUS [RW]                            0x005830DC"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x00000003    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_EPRB0_SPROF_FILTERS_2_STATUS PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   1.           "[ 1 ]      RSPEN                               = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   0.           "[ 0 ]      REQEN                               = " "0x00 (?),0x01 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x005830DC$ PER_TESLA9X45_Part5.per -queue SNOC_EPRB0_SPROF_FILTERS_2_STATUS"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x005830E0
tree " SNOC_EPRB0_SPROF_FILTERS_2_LENGTH [RW]                            0x005830E0"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x0000000F    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_EPRB0_SPROF_FILTERS_2_LENGTH PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   0.--3.       "[3 : 0]    FILTERS_2_LENGTH                    = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?),0x08 (?),0x09 (?),0x0A (?),0x0B (?),0x0C (?),0x0D (?),0x0E (?),0x0F (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x005830E0$ PER_TESLA9X45_Part5.per -queue SNOC_EPRB0_SPROF_FILTERS_2_LENGTH"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x005830E4
tree " SNOC_EPRB0_SPROF_FILTERS_2_URGENCY [RW]                           0x005830E4"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x00000003    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_EPRB0_SPROF_FILTERS_2_URGENCY PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   0.--1.       "[1 : 0]    FILTERS_2_URGENCY                   = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x005830E4$ PER_TESLA9X45_Part5.per -queue SNOC_EPRB0_SPROF_FILTERS_2_URGENCY"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x005830F8
tree " SNOC_EPRB0_SPROF_FILTERS_3_ROUTEIDBASE [RW]                       0x005830F8"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x1FFFFFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_EPRB0_SPROF_FILTERS_3_ROUTEIDBASE PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.long 0 0.--28. 1  "[28 : 0]   FILTERS_3_ROUTEIDBASE               = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x005830F8$ PER_TESLA9X45_Part5.per -queue SNOC_EPRB0_SPROF_FILTERS_3_ROUTEIDBASE"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x005830FC
tree " SNOC_EPRB0_SPROF_FILTERS_3_ROUTEIDMASK [RW]                       0x005830FC"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x1FFFFFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_EPRB0_SPROF_FILTERS_3_ROUTEIDMASK PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.long 0 0.--28. 1  "[28 : 0]   FILTERS_3_ROUTEIDMASK               = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x005830FC$ PER_TESLA9X45_Part5.per -queue SNOC_EPRB0_SPROF_FILTERS_3_ROUTEIDMASK"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00583100
tree " SNOC_EPRB0_SPROF_FILTERS_3_ADDRBASE_LOW [RW]                      0x00583100"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0xFFFFFFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_EPRB0_SPROF_FILTERS_3_ADDRBASE_LOW PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.long 0 0.--31. 1  "[31 : 0]   FILTERS_3_ADDRBASE_LOW              = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00583100$ PER_TESLA9X45_Part5.per -queue SNOC_EPRB0_SPROF_FILTERS_3_ADDRBASE_LOW"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00583104
tree " SNOC_EPRB0_SPROF_FILTERS_3_ADDRBASE_HIGH [RW]                     0x00583104"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x00000001    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_EPRB0_SPROF_FILTERS_3_ADDRBASE_HIGH PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   0.           "[ 0 ]      FILTERS_3_ADDRBASE_HIGH             = " "0x00 (?),0x01 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00583104$ PER_TESLA9X45_Part5.per -queue SNOC_EPRB0_SPROF_FILTERS_3_ADDRBASE_HIGH"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00583108
tree " SNOC_EPRB0_SPROF_FILTERS_3_WINDOWSIZE [RW]                        0x00583108"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x0000003F    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_EPRB0_SPROF_FILTERS_3_WINDOWSIZE PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   0.--5.       "[5 : 0]    FILTERS_3_WINDOWSIZE                = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?),0x08 (?),0x09 (?),0x0A (?),0x0B (?),0x0C (?),0x0D (?),0x0E (?),0x0F (?),0x10 (?),0x11 (?),0x12 (?),0x13 (?),0x14 (?),0x15 (?),0x16 (?),0x17 (?),0x18 (?),0x19 (?),0x1A (?),0x1B (?),0x1C (?),0x1D (?),0x1E (?),0x1F (?),0x20 (?),0x21 (?),0x22 (?),0x23 (?),0x24 (?),0x25 (?),0x26 (?),0x27 (?),0x28 (?),0x29 (?),0x2A (?),0x2B (?),0x2C (?),0x2D (?),0x2E (?),0x2F (?),0x30 (?),0x31 (?),0x32 (?),0x33 (?),0x34 (?),0x35 (?),0x36 (?),0x37 (?),0x38 (?),0x39 (?),0x3A (?),0x3B (?),0x3C (?),0x3D (?),0x3E (?),0x3F (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00583108$ PER_TESLA9X45_Part5.per -queue SNOC_EPRB0_SPROF_FILTERS_3_WINDOWSIZE"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00583114
tree " SNOC_EPRB0_SPROF_FILTERS_3_OPCODE [RW]                            0x00583114"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x0000000F    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_EPRB0_SPROF_FILTERS_3_OPCODE PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   3.           "[ 3 ]      URGEN                               = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   2.           "[ 2 ]      LOCKEN                              = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   1.           "[ 1 ]      WREN                                = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   0.           "[ 0 ]      RDEN                                = " "0x00 (?),0x01 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00583114$ PER_TESLA9X45_Part5.per -queue SNOC_EPRB0_SPROF_FILTERS_3_OPCODE"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00583118
tree " SNOC_EPRB0_SPROF_FILTERS_3_STATUS [RW]                            0x00583118"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x00000003    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_EPRB0_SPROF_FILTERS_3_STATUS PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   1.           "[ 1 ]      RSPEN                               = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   0.           "[ 0 ]      REQEN                               = " "0x00 (?),0x01 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00583118$ PER_TESLA9X45_Part5.per -queue SNOC_EPRB0_SPROF_FILTERS_3_STATUS"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0058311C
tree " SNOC_EPRB0_SPROF_FILTERS_3_LENGTH [RW]                            0x0058311C"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x0000000F    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_EPRB0_SPROF_FILTERS_3_LENGTH PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   0.--3.       "[3 : 0]    FILTERS_3_LENGTH                    = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?),0x08 (?),0x09 (?),0x0A (?),0x0B (?),0x0C (?),0x0D (?),0x0E (?),0x0F (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0058311C$ PER_TESLA9X45_Part5.per -queue SNOC_EPRB0_SPROF_FILTERS_3_LENGTH"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00583120
tree " SNOC_EPRB0_SPROF_FILTERS_3_URGENCY [RW]                           0x00583120"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x00000003    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_EPRB0_SPROF_FILTERS_3_URGENCY PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   0.--1.       "[1 : 0]    FILTERS_3_URGENCY                   = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00583120$ PER_TESLA9X45_Part5.per -queue SNOC_EPRB0_SPROF_FILTERS_3_URGENCY"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00583134
tree " SNOC_EPRB0_SPROF_COUNTERS_0_PORTSEL [RW]                          0x00583134"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = undef         "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_EPRB0_SPROF_COUNTERS_0_PORTSEL PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   0.--1.       "[1 : 0]    COUNTERS_0_PORTSEL                  = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00583134$ PER_TESLA9X45_Part5.per -queue SNOC_EPRB0_SPROF_COUNTERS_0_PORTSEL"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00583138
tree " SNOC_EPRB0_SPROF_COUNTERS_0_SRC [RW]                              0x00583138"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x0000001F    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_EPRB0_SPROF_COUNTERS_0_SRC PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   0.--4.       "[4 : 0]    INTEVENT                            = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?),0x08 (?),0x09 (?),0x0A (?),0x0B (?),0x0C (?),0x0D (?),0x0E (?),0x0F (?),0x10 (?),0x11 (?),0x12 (?),0x13 (?),0x14 (?),0x15 (?),0x16 (?),0x17 (?),0x18 (?),0x19 (?),0x1A (?),0x1B (?),0x1C (?),0x1D (?),0x1E (?),0x1F (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00583138$ PER_TESLA9X45_Part5.per -queue SNOC_EPRB0_SPROF_COUNTERS_0_SRC"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0058313C
tree " SNOC_EPRB0_SPROF_COUNTERS_0_ALARMMODE [RW]                        0x0058313C"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x00000003    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_EPRB0_SPROF_COUNTERS_0_ALARMMODE PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   0.--1.       "[1 : 0]    COUNTERS_0_ALARMMODE                = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0058313C$ PER_TESLA9X45_Part5.per -queue SNOC_EPRB0_SPROF_COUNTERS_0_ALARMMODE"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00583140
tree " SNOC_EPRB0_SPROF_COUNTERS_0_VAL [R]                               0x00583140"
  group.long 0x0--0x3
   textline "POR 0xDEADBEEF [0xxxxxxxxx]    MASK =  "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_EPRB0_SPROF_COUNTERS_0_VAL PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.word 0 0.--15. 1  "[15 : 0]   COUNTERS_0_VAL                      = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00583140$ PER_TESLA9X45_Part5.per -queue SNOC_EPRB0_SPROF_COUNTERS_0_VAL"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00583148
tree " SNOC_EPRB0_SPROF_COUNTERS_1_PORTSEL [RW]                          0x00583148"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = undef         "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_EPRB0_SPROF_COUNTERS_1_PORTSEL PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   0.--1.       "[1 : 0]    COUNTERS_1_PORTSEL                  = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00583148$ PER_TESLA9X45_Part5.per -queue SNOC_EPRB0_SPROF_COUNTERS_1_PORTSEL"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0058314C
tree " SNOC_EPRB0_SPROF_COUNTERS_1_SRC [RW]                              0x0058314C"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x0000001F    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_EPRB0_SPROF_COUNTERS_1_SRC PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   0.--4.       "[4 : 0]    INTEVENT                            = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?),0x08 (?),0x09 (?),0x0A (?),0x0B (?),0x0C (?),0x0D (?),0x0E (?),0x0F (?),0x10 (?),0x11 (?),0x12 (?),0x13 (?),0x14 (?),0x15 (?),0x16 (?),0x17 (?),0x18 (?),0x19 (?),0x1A (?),0x1B (?),0x1C (?),0x1D (?),0x1E (?),0x1F (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0058314C$ PER_TESLA9X45_Part5.per -queue SNOC_EPRB0_SPROF_COUNTERS_1_SRC"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00583150
tree " SNOC_EPRB0_SPROF_COUNTERS_1_ALARMMODE [RW]                        0x00583150"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x00000003    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_EPRB0_SPROF_COUNTERS_1_ALARMMODE PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   0.--1.       "[1 : 0]    COUNTERS_1_ALARMMODE                = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00583150$ PER_TESLA9X45_Part5.per -queue SNOC_EPRB0_SPROF_COUNTERS_1_ALARMMODE"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00583154
tree " SNOC_EPRB0_SPROF_COUNTERS_1_VAL [R]                               0x00583154"
  group.long 0x0--0x3
   textline "POR 0xDEADBEEF [0xxxxxxxxx]    MASK =  "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_EPRB0_SPROF_COUNTERS_1_VAL PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.word 0 0.--15. 1  "[15 : 0]   COUNTERS_1_VAL                      = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00583154$ PER_TESLA9X45_Part5.per -queue SNOC_EPRB0_SPROF_COUNTERS_1_VAL"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0058315C
tree " SNOC_EPRB0_SPROF_COUNTERS_2_PORTSEL [RW]                          0x0058315C"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = undef         "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_EPRB0_SPROF_COUNTERS_2_PORTSEL PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   0.--1.       "[1 : 0]    COUNTERS_2_PORTSEL                  = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0058315C$ PER_TESLA9X45_Part5.per -queue SNOC_EPRB0_SPROF_COUNTERS_2_PORTSEL"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00583160
tree " SNOC_EPRB0_SPROF_COUNTERS_2_SRC [RW]                              0x00583160"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x0000001F    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_EPRB0_SPROF_COUNTERS_2_SRC PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   0.--4.       "[4 : 0]    INTEVENT                            = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?),0x08 (?),0x09 (?),0x0A (?),0x0B (?),0x0C (?),0x0D (?),0x0E (?),0x0F (?),0x10 (?),0x11 (?),0x12 (?),0x13 (?),0x14 (?),0x15 (?),0x16 (?),0x17 (?),0x18 (?),0x19 (?),0x1A (?),0x1B (?),0x1C (?),0x1D (?),0x1E (?),0x1F (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00583160$ PER_TESLA9X45_Part5.per -queue SNOC_EPRB0_SPROF_COUNTERS_2_SRC"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00583164
tree " SNOC_EPRB0_SPROF_COUNTERS_2_ALARMMODE [RW]                        0x00583164"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x00000003    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_EPRB0_SPROF_COUNTERS_2_ALARMMODE PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   0.--1.       "[1 : 0]    COUNTERS_2_ALARMMODE                = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00583164$ PER_TESLA9X45_Part5.per -queue SNOC_EPRB0_SPROF_COUNTERS_2_ALARMMODE"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00583168
tree " SNOC_EPRB0_SPROF_COUNTERS_2_VAL [R]                               0x00583168"
  group.long 0x0--0x3
   textline "POR 0xDEADBEEF [0xxxxxxxxx]    MASK =  "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_EPRB0_SPROF_COUNTERS_2_VAL PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.word 0 0.--15. 1  "[15 : 0]   COUNTERS_2_VAL                      = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00583168$ PER_TESLA9X45_Part5.per -queue SNOC_EPRB0_SPROF_COUNTERS_2_VAL"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00583170
tree " SNOC_EPRB0_SPROF_COUNTERS_3_PORTSEL [RW]                          0x00583170"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = undef         "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_EPRB0_SPROF_COUNTERS_3_PORTSEL PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   0.--1.       "[1 : 0]    COUNTERS_3_PORTSEL                  = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00583170$ PER_TESLA9X45_Part5.per -queue SNOC_EPRB0_SPROF_COUNTERS_3_PORTSEL"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00583174
tree " SNOC_EPRB0_SPROF_COUNTERS_3_SRC [RW]                              0x00583174"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x0000001F    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_EPRB0_SPROF_COUNTERS_3_SRC PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   0.--4.       "[4 : 0]    INTEVENT                            = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?),0x08 (?),0x09 (?),0x0A (?),0x0B (?),0x0C (?),0x0D (?),0x0E (?),0x0F (?),0x10 (?),0x11 (?),0x12 (?),0x13 (?),0x14 (?),0x15 (?),0x16 (?),0x17 (?),0x18 (?),0x19 (?),0x1A (?),0x1B (?),0x1C (?),0x1D (?),0x1E (?),0x1F (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00583174$ PER_TESLA9X45_Part5.per -queue SNOC_EPRB0_SPROF_COUNTERS_3_SRC"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00583178
tree " SNOC_EPRB0_SPROF_COUNTERS_3_ALARMMODE [RW]                        0x00583178"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x00000003    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_EPRB0_SPROF_COUNTERS_3_ALARMMODE PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   0.--1.       "[1 : 0]    COUNTERS_3_ALARMMODE                = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00583178$ PER_TESLA9X45_Part5.per -queue SNOC_EPRB0_SPROF_COUNTERS_3_ALARMMODE"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0058317C
tree " SNOC_EPRB0_SPROF_COUNTERS_3_VAL [R]                               0x0058317C"
  group.long 0x0--0x3
   textline "POR 0xDEADBEEF [0xxxxxxxxx]    MASK =  "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_EPRB0_SPROF_COUNTERS_3_VAL PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.word 0 0.--15. 1  "[15 : 0]   COUNTERS_3_VAL                      = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0058317C$ PER_TESLA9X45_Part5.per -queue SNOC_EPRB0_SPROF_COUNTERS_3_VAL"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00583184
tree " SNOC_EPRB0_SPROF_COUNTERS_4_PORTSEL [RW]                          0x00583184"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = undef         "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_EPRB0_SPROF_COUNTERS_4_PORTSEL PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   0.--1.       "[1 : 0]    COUNTERS_4_PORTSEL                  = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00583184$ PER_TESLA9X45_Part5.per -queue SNOC_EPRB0_SPROF_COUNTERS_4_PORTSEL"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00583188
tree " SNOC_EPRB0_SPROF_COUNTERS_4_SRC [RW]                              0x00583188"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x0000001F    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_EPRB0_SPROF_COUNTERS_4_SRC PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   0.--4.       "[4 : 0]    INTEVENT                            = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?),0x08 (?),0x09 (?),0x0A (?),0x0B (?),0x0C (?),0x0D (?),0x0E (?),0x0F (?),0x10 (?),0x11 (?),0x12 (?),0x13 (?),0x14 (?),0x15 (?),0x16 (?),0x17 (?),0x18 (?),0x19 (?),0x1A (?),0x1B (?),0x1C (?),0x1D (?),0x1E (?),0x1F (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00583188$ PER_TESLA9X45_Part5.per -queue SNOC_EPRB0_SPROF_COUNTERS_4_SRC"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0058318C
tree " SNOC_EPRB0_SPROF_COUNTERS_4_ALARMMODE [RW]                        0x0058318C"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x00000003    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_EPRB0_SPROF_COUNTERS_4_ALARMMODE PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   0.--1.       "[1 : 0]    COUNTERS_4_ALARMMODE                = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0058318C$ PER_TESLA9X45_Part5.per -queue SNOC_EPRB0_SPROF_COUNTERS_4_ALARMMODE"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00583190
tree " SNOC_EPRB0_SPROF_COUNTERS_4_VAL [R]                               0x00583190"
  group.long 0x0--0x3
   textline "POR 0xDEADBEEF [0xxxxxxxxx]    MASK =  "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_EPRB0_SPROF_COUNTERS_4_VAL PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.word 0 0.--15. 1  "[15 : 0]   COUNTERS_4_VAL                      = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00583190$ PER_TESLA9X45_Part5.per -queue SNOC_EPRB0_SPROF_COUNTERS_4_VAL"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00583198
tree " SNOC_EPRB0_SPROF_COUNTERS_5_PORTSEL [RW]                          0x00583198"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = undef         "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_EPRB0_SPROF_COUNTERS_5_PORTSEL PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   0.--1.       "[1 : 0]    COUNTERS_5_PORTSEL                  = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00583198$ PER_TESLA9X45_Part5.per -queue SNOC_EPRB0_SPROF_COUNTERS_5_PORTSEL"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0058319C
tree " SNOC_EPRB0_SPROF_COUNTERS_5_SRC [RW]                              0x0058319C"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x0000001F    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_EPRB0_SPROF_COUNTERS_5_SRC PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   0.--4.       "[4 : 0]    INTEVENT                            = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?),0x08 (?),0x09 (?),0x0A (?),0x0B (?),0x0C (?),0x0D (?),0x0E (?),0x0F (?),0x10 (?),0x11 (?),0x12 (?),0x13 (?),0x14 (?),0x15 (?),0x16 (?),0x17 (?),0x18 (?),0x19 (?),0x1A (?),0x1B (?),0x1C (?),0x1D (?),0x1E (?),0x1F (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0058319C$ PER_TESLA9X45_Part5.per -queue SNOC_EPRB0_SPROF_COUNTERS_5_SRC"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x005831A0
tree " SNOC_EPRB0_SPROF_COUNTERS_5_ALARMMODE [RW]                        0x005831A0"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x00000003    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_EPRB0_SPROF_COUNTERS_5_ALARMMODE PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   0.--1.       "[1 : 0]    COUNTERS_5_ALARMMODE                = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x005831A0$ PER_TESLA9X45_Part5.per -queue SNOC_EPRB0_SPROF_COUNTERS_5_ALARMMODE"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x005831A4
tree " SNOC_EPRB0_SPROF_COUNTERS_5_VAL [R]                               0x005831A4"
  group.long 0x0--0x3
   textline "POR 0xDEADBEEF [0xxxxxxxxx]    MASK =  "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_EPRB0_SPROF_COUNTERS_5_VAL PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.word 0 0.--15. 1  "[15 : 0]   COUNTERS_5_VAL                      = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x005831A4$ PER_TESLA9X45_Part5.per -queue SNOC_EPRB0_SPROF_COUNTERS_5_VAL"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x005831AC
tree " SNOC_EPRB0_SPROF_COUNTERS_6_PORTSEL [RW]                          0x005831AC"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = undef         "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_EPRB0_SPROF_COUNTERS_6_PORTSEL PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   0.--1.       "[1 : 0]    COUNTERS_6_PORTSEL                  = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x005831AC$ PER_TESLA9X45_Part5.per -queue SNOC_EPRB0_SPROF_COUNTERS_6_PORTSEL"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x005831B0
tree " SNOC_EPRB0_SPROF_COUNTERS_6_SRC [RW]                              0x005831B0"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x0000001F    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_EPRB0_SPROF_COUNTERS_6_SRC PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   0.--4.       "[4 : 0]    INTEVENT                            = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?),0x08 (?),0x09 (?),0x0A (?),0x0B (?),0x0C (?),0x0D (?),0x0E (?),0x0F (?),0x10 (?),0x11 (?),0x12 (?),0x13 (?),0x14 (?),0x15 (?),0x16 (?),0x17 (?),0x18 (?),0x19 (?),0x1A (?),0x1B (?),0x1C (?),0x1D (?),0x1E (?),0x1F (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x005831B0$ PER_TESLA9X45_Part5.per -queue SNOC_EPRB0_SPROF_COUNTERS_6_SRC"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x005831B4
tree " SNOC_EPRB0_SPROF_COUNTERS_6_ALARMMODE [RW]                        0x005831B4"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x00000003    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_EPRB0_SPROF_COUNTERS_6_ALARMMODE PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   0.--1.       "[1 : 0]    COUNTERS_6_ALARMMODE                = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x005831B4$ PER_TESLA9X45_Part5.per -queue SNOC_EPRB0_SPROF_COUNTERS_6_ALARMMODE"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x005831B8
tree " SNOC_EPRB0_SPROF_COUNTERS_6_VAL [R]                               0x005831B8"
  group.long 0x0--0x3
   textline "POR 0xDEADBEEF [0xxxxxxxxx]    MASK =  "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_EPRB0_SPROF_COUNTERS_6_VAL PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.word 0 0.--15. 1  "[15 : 0]   COUNTERS_6_VAL                      = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x005831B8$ PER_TESLA9X45_Part5.per -queue SNOC_EPRB0_SPROF_COUNTERS_6_VAL"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x005831C0
tree " SNOC_EPRB0_SPROF_COUNTERS_7_PORTSEL [RW]                          0x005831C0"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = undef         "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_EPRB0_SPROF_COUNTERS_7_PORTSEL PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   0.--1.       "[1 : 0]    COUNTERS_7_PORTSEL                  = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x005831C0$ PER_TESLA9X45_Part5.per -queue SNOC_EPRB0_SPROF_COUNTERS_7_PORTSEL"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x005831C4
tree " SNOC_EPRB0_SPROF_COUNTERS_7_SRC [RW]                              0x005831C4"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x0000001F    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_EPRB0_SPROF_COUNTERS_7_SRC PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   0.--4.       "[4 : 0]    INTEVENT                            = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?),0x08 (?),0x09 (?),0x0A (?),0x0B (?),0x0C (?),0x0D (?),0x0E (?),0x0F (?),0x10 (?),0x11 (?),0x12 (?),0x13 (?),0x14 (?),0x15 (?),0x16 (?),0x17 (?),0x18 (?),0x19 (?),0x1A (?),0x1B (?),0x1C (?),0x1D (?),0x1E (?),0x1F (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x005831C4$ PER_TESLA9X45_Part5.per -queue SNOC_EPRB0_SPROF_COUNTERS_7_SRC"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x005831C8
tree " SNOC_EPRB0_SPROF_COUNTERS_7_ALARMMODE [RW]                        0x005831C8"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x00000003    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_EPRB0_SPROF_COUNTERS_7_ALARMMODE PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   0.--1.       "[1 : 0]    COUNTERS_7_ALARMMODE                = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x005831C8$ PER_TESLA9X45_Part5.per -queue SNOC_EPRB0_SPROF_COUNTERS_7_ALARMMODE"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x005831CC
tree " SNOC_EPRB0_SPROF_COUNTERS_7_VAL [R]                               0x005831CC"
  group.long 0x0--0x3
   textline "POR 0xDEADBEEF [0xxxxxxxxx]    MASK =  "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_EPRB0_SPROF_COUNTERS_7_VAL PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.word 0 0.--15. 1  "[15 : 0]   COUNTERS_7_VAL                      = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x005831CC$ PER_TESLA9X45_Part5.per -queue SNOC_EPRB0_SPROF_COUNTERS_7_VAL"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x005831D4
tree " SNOC_EPRB0_SPROF_COUNTERS_8_PORTSEL [RW]                          0x005831D4"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = undef         "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_EPRB0_SPROF_COUNTERS_8_PORTSEL PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   0.--1.       "[1 : 0]    COUNTERS_8_PORTSEL                  = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x005831D4$ PER_TESLA9X45_Part5.per -queue SNOC_EPRB0_SPROF_COUNTERS_8_PORTSEL"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x005831D8
tree " SNOC_EPRB0_SPROF_COUNTERS_8_SRC [RW]                              0x005831D8"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x0000001F    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_EPRB0_SPROF_COUNTERS_8_SRC PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   0.--4.       "[4 : 0]    INTEVENT                            = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?),0x08 (?),0x09 (?),0x0A (?),0x0B (?),0x0C (?),0x0D (?),0x0E (?),0x0F (?),0x10 (?),0x11 (?),0x12 (?),0x13 (?),0x14 (?),0x15 (?),0x16 (?),0x17 (?),0x18 (?),0x19 (?),0x1A (?),0x1B (?),0x1C (?),0x1D (?),0x1E (?),0x1F (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x005831D8$ PER_TESLA9X45_Part5.per -queue SNOC_EPRB0_SPROF_COUNTERS_8_SRC"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x005831DC
tree " SNOC_EPRB0_SPROF_COUNTERS_8_ALARMMODE [RW]                        0x005831DC"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x00000003    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_EPRB0_SPROF_COUNTERS_8_ALARMMODE PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   0.--1.       "[1 : 0]    COUNTERS_8_ALARMMODE                = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x005831DC$ PER_TESLA9X45_Part5.per -queue SNOC_EPRB0_SPROF_COUNTERS_8_ALARMMODE"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x005831E0
tree " SNOC_EPRB0_SPROF_COUNTERS_8_VAL [R]                               0x005831E0"
  group.long 0x0--0x3
   textline "POR 0xDEADBEEF [0xxxxxxxxx]    MASK =  "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_EPRB0_SPROF_COUNTERS_8_VAL PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.word 0 0.--15. 1  "[15 : 0]   COUNTERS_8_VAL                      = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x005831E0$ PER_TESLA9X45_Part5.per -queue SNOC_EPRB0_SPROF_COUNTERS_8_VAL"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x005831E8
tree " SNOC_EPRB0_SPROF_COUNTERS_9_PORTSEL [RW]                          0x005831E8"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = undef         "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_EPRB0_SPROF_COUNTERS_9_PORTSEL PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   0.--1.       "[1 : 0]    COUNTERS_9_PORTSEL                  = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x005831E8$ PER_TESLA9X45_Part5.per -queue SNOC_EPRB0_SPROF_COUNTERS_9_PORTSEL"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x005831EC
tree " SNOC_EPRB0_SPROF_COUNTERS_9_SRC [RW]                              0x005831EC"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x0000001F    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_EPRB0_SPROF_COUNTERS_9_SRC PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   0.--4.       "[4 : 0]    INTEVENT                            = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?),0x08 (?),0x09 (?),0x0A (?),0x0B (?),0x0C (?),0x0D (?),0x0E (?),0x0F (?),0x10 (?),0x11 (?),0x12 (?),0x13 (?),0x14 (?),0x15 (?),0x16 (?),0x17 (?),0x18 (?),0x19 (?),0x1A (?),0x1B (?),0x1C (?),0x1D (?),0x1E (?),0x1F (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x005831EC$ PER_TESLA9X45_Part5.per -queue SNOC_EPRB0_SPROF_COUNTERS_9_SRC"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x005831F0
tree " SNOC_EPRB0_SPROF_COUNTERS_9_ALARMMODE [RW]                        0x005831F0"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x00000003    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_EPRB0_SPROF_COUNTERS_9_ALARMMODE PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   0.--1.       "[1 : 0]    COUNTERS_9_ALARMMODE                = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x005831F0$ PER_TESLA9X45_Part5.per -queue SNOC_EPRB0_SPROF_COUNTERS_9_ALARMMODE"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x005831F4
tree " SNOC_EPRB0_SPROF_COUNTERS_9_VAL [R]                               0x005831F4"
  group.long 0x0--0x3
   textline "POR 0xDEADBEEF [0xxxxxxxxx]    MASK =  "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_EPRB0_SPROF_COUNTERS_9_VAL PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.word 0 0.--15. 1  "[15 : 0]   COUNTERS_9_VAL                      = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x005831F4$ PER_TESLA9X45_Part5.per -queue SNOC_EPRB0_SPROF_COUNTERS_9_VAL"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00583400
tree " SNOC_EPRB1_SPROF_ID_COREID [R]                                    0x00583400"
  group.long 0x0--0x3
   textline "POR 0xD30A3406    MASK = 0xFFFFFFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_EPRB1_SPROF_ID_COREID PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.long 0 8.--31. 1  "[31 : 8]   CORECHECKSUM                        = "
   textline ""
   hexmask.long.byte 0 0.--7. 1   "[7 : 0]    CORETYPEID                          = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00583400$ PER_TESLA9X45_Part5.per -queue SNOC_EPRB1_SPROF_ID_COREID"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00583404
tree " SNOC_EPRB1_SPROF_ID_REVISIONID [R]                                0x00583404"
  group.long 0x0--0x3
   textline "POR 0x00049C00    MASK = 0xFFFFFFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_EPRB1_SPROF_ID_REVISIONID PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.long 0 8.--31. 1  "[31 : 8]   FLEXNOCID                           = "
   textline ""
   hexmask.long.byte 0 0.--7. 1   "[7 : 0]    USERID                              = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00583404$ PER_TESLA9X45_Part5.per -queue SNOC_EPRB1_SPROF_ID_REVISIONID"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00583408
tree " SNOC_EPRB1_SPROF_MAINCTL [RW]                                     0x00583408"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x000000FF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_EPRB1_SPROF_MAINCTL PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   7.           "[ 7 ]      FILTBYTEALWAYSCHAINABLEEN           = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   6.           "[ 6 ]      INTRUSIVEMODE                       = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   5.           "[ 5 ]      STATCONDDUMP                        = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   4.           "[ 4 ]      ALARMEN                             = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   3.           "[ 3 ]      STATEN                              = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   2.           "[ 2 ]      PAYLOADEN                           = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   1.           "[ 1 ]      TRACEEN                             = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   0.           "[ 0 ]      ERREN                               = " "0x00 (?),0x01 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00583408$ PER_TESLA9X45_Part5.per -queue SNOC_EPRB1_SPROF_MAINCTL"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0058340C
tree " SNOC_EPRB1_SPROF_CFGCTL [RW]                                      0x0058340C"
  group.long 0x0--0x3
   textline "POR 0xDEADBEEF [0xxxxxxxxx]    MASK =  "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_EPRB1_SPROF_CFGCTL PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   1.           "[ 1 ]      ACTIVE                              = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   0.           "[ 0 ]      GLOBALEN                            = " "0x00 (?),0x01 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0058340C$ PER_TESLA9X45_Part5.per -queue SNOC_EPRB1_SPROF_CFGCTL"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00583410
tree " SNOC_EPRB1_SPROF_TRACEPORTSEL [RW]                                0x00583410"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = undef         "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_EPRB1_SPROF_TRACEPORTSEL PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   0.--1.       "[1 : 0]    TRACEPORTSEL                        = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00583410$ PER_TESLA9X45_Part5.per -queue SNOC_EPRB1_SPROF_TRACEPORTSEL"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00583414
tree " SNOC_EPRB1_SPROF_FILTERLUT [RW]                                   0x00583414"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x0000FFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_EPRB1_SPROF_FILTERLUT PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.word 0 0.--15. 1  "[15 : 0]   FILTERLUT                           = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00583414$ PER_TESLA9X45_Part5.per -queue SNOC_EPRB1_SPROF_FILTERLUT"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00583418
tree " SNOC_EPRB1_SPROF_TRACEALARMEN [RW]                                0x00583418"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x0000001F    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_EPRB1_SPROF_TRACEALARMEN PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   0.--4.       "[4 : 0]    TRACEALARMEN                        = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?),0x08 (?),0x09 (?),0x0A (?),0x0B (?),0x0C (?),0x0D (?),0x0E (?),0x0F (?),0x10 (?),0x11 (?),0x12 (?),0x13 (?),0x14 (?),0x15 (?),0x16 (?),0x17 (?),0x18 (?),0x19 (?),0x1A (?),0x1B (?),0x1C (?),0x1D (?),0x1E (?),0x1F (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00583418$ PER_TESLA9X45_Part5.per -queue SNOC_EPRB1_SPROF_TRACEALARMEN"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0058341C
tree " SNOC_EPRB1_SPROF_TRACEALARMSTATUS [R]                             0x0058341C"
  group.long 0x0--0x3
   textline "POR 0xDEADBEEF [0xxxxxxxxx]    MASK =  "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_EPRB1_SPROF_TRACEALARMSTATUS PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   0.--4.       "[4 : 0]    TRACEALARMSTATUS                    = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?),0x08 (?),0x09 (?),0x0A (?),0x0B (?),0x0C (?),0x0D (?),0x0E (?),0x0F (?),0x10 (?),0x11 (?),0x12 (?),0x13 (?),0x14 (?),0x15 (?),0x16 (?),0x17 (?),0x18 (?),0x19 (?),0x1A (?),0x1B (?),0x1C (?),0x1D (?),0x1E (?),0x1F (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0058341C$ PER_TESLA9X45_Part5.per -queue SNOC_EPRB1_SPROF_TRACEALARMSTATUS"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00583420
tree " SNOC_EPRB1_SPROF_TRACEALARMCLR [RW]                               0x00583420"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x0000001F    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_EPRB1_SPROF_TRACEALARMCLR PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   0.--4.       "[4 : 0]    TRACEALARMCLR                       = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?),0x08 (?),0x09 (?),0x0A (?),0x0B (?),0x0C (?),0x0D (?),0x0E (?),0x0F (?),0x10 (?),0x11 (?),0x12 (?),0x13 (?),0x14 (?),0x15 (?),0x16 (?),0x17 (?),0x18 (?),0x19 (?),0x1A (?),0x1B (?),0x1C (?),0x1D (?),0x1E (?),0x1F (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00583420$ PER_TESLA9X45_Part5.per -queue SNOC_EPRB1_SPROF_TRACEALARMCLR"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00583424
tree " SNOC_EPRB1_SPROF_STATPERIOD [RW]                                  0x00583424"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x0000001F    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_EPRB1_SPROF_STATPERIOD PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   0.--4.       "[4 : 0]    STATPERIOD                          = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?),0x08 (?),0x09 (?),0x0A (?),0x0B (?),0x0C (?),0x0D (?),0x0E (?),0x0F (?),0x10 (?),0x11 (?),0x12 (?),0x13 (?),0x14 (?),0x15 (?),0x16 (?),0x17 (?),0x18 (?),0x19 (?),0x1A (?),0x1B (?),0x1C (?),0x1D (?),0x1E (?),0x1F (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00583424$ PER_TESLA9X45_Part5.per -queue SNOC_EPRB1_SPROF_STATPERIOD"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00583428
tree " SNOC_EPRB1_SPROF_STATGO [RW]                                      0x00583428"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x00000001    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_EPRB1_SPROF_STATGO PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   0.           "[ 0 ]      STATGO                              = " "0x00 (?),0x01 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00583428$ PER_TESLA9X45_Part5.per -queue SNOC_EPRB1_SPROF_STATGO"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0058342C
tree " SNOC_EPRB1_SPROF_STATALARMMIN [RW]                                0x0058342C"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0xFFFFFFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_EPRB1_SPROF_STATALARMMIN PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.long 0 0.--31. 1  "[31 : 0]   STATALARMMIN                        = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0058342C$ PER_TESLA9X45_Part5.per -queue SNOC_EPRB1_SPROF_STATALARMMIN"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00583430
tree " SNOC_EPRB1_SPROF_STATALARMMAX [RW]                                0x00583430"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0xFFFFFFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_EPRB1_SPROF_STATALARMMAX PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.long 0 0.--31. 1  "[31 : 0]   STATALARMMAX                        = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00583430$ PER_TESLA9X45_Part5.per -queue SNOC_EPRB1_SPROF_STATALARMMAX"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00583434
tree " SNOC_EPRB1_SPROF_STATALARMSTATUS [R]                              0x00583434"
  group.long 0x0--0x3
   textline "POR 0xDEADBEEF [0xxxxxxxxx]    MASK =  "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_EPRB1_SPROF_STATALARMSTATUS PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   0.           "[ 0 ]      STATALARMSTATUS                     = " "0x00 (?),0x01 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00583434$ PER_TESLA9X45_Part5.per -queue SNOC_EPRB1_SPROF_STATALARMSTATUS"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00583438
tree " SNOC_EPRB1_SPROF_STATALARMCLR [RW]                                0x00583438"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x00000001    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_EPRB1_SPROF_STATALARMCLR PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   0.           "[ 0 ]      STATALARMCLR                        = " "0x00 (?),0x01 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00583438$ PER_TESLA9X45_Part5.per -queue SNOC_EPRB1_SPROF_STATALARMCLR"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00583444
tree " SNOC_EPRB1_SPROF_FILTERS_0_ROUTEIDBASE [RW]                       0x00583444"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x1FFFFFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_EPRB1_SPROF_FILTERS_0_ROUTEIDBASE PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.long 0 0.--28. 1  "[28 : 0]   FILTERS_0_ROUTEIDBASE               = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00583444$ PER_TESLA9X45_Part5.per -queue SNOC_EPRB1_SPROF_FILTERS_0_ROUTEIDBASE"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00583448
tree " SNOC_EPRB1_SPROF_FILTERS_0_ROUTEIDMASK [RW]                       0x00583448"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x1FFFFFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_EPRB1_SPROF_FILTERS_0_ROUTEIDMASK PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.long 0 0.--28. 1  "[28 : 0]   FILTERS_0_ROUTEIDMASK               = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00583448$ PER_TESLA9X45_Part5.per -queue SNOC_EPRB1_SPROF_FILTERS_0_ROUTEIDMASK"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0058344C
tree " SNOC_EPRB1_SPROF_FILTERS_0_ADDRBASE_LOW [RW]                      0x0058344C"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0xFFFFFFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_EPRB1_SPROF_FILTERS_0_ADDRBASE_LOW PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.long 0 0.--31. 1  "[31 : 0]   FILTERS_0_ADDRBASE_LOW              = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0058344C$ PER_TESLA9X45_Part5.per -queue SNOC_EPRB1_SPROF_FILTERS_0_ADDRBASE_LOW"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00583450
tree " SNOC_EPRB1_SPROF_FILTERS_0_ADDRBASE_HIGH [RW]                     0x00583450"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x00000001    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_EPRB1_SPROF_FILTERS_0_ADDRBASE_HIGH PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   0.           "[ 0 ]      FILTERS_0_ADDRBASE_HIGH             = " "0x00 (?),0x01 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00583450$ PER_TESLA9X45_Part5.per -queue SNOC_EPRB1_SPROF_FILTERS_0_ADDRBASE_HIGH"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00583454
tree " SNOC_EPRB1_SPROF_FILTERS_0_WINDOWSIZE [RW]                        0x00583454"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x0000003F    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_EPRB1_SPROF_FILTERS_0_WINDOWSIZE PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   0.--5.       "[5 : 0]    FILTERS_0_WINDOWSIZE                = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?),0x08 (?),0x09 (?),0x0A (?),0x0B (?),0x0C (?),0x0D (?),0x0E (?),0x0F (?),0x10 (?),0x11 (?),0x12 (?),0x13 (?),0x14 (?),0x15 (?),0x16 (?),0x17 (?),0x18 (?),0x19 (?),0x1A (?),0x1B (?),0x1C (?),0x1D (?),0x1E (?),0x1F (?),0x20 (?),0x21 (?),0x22 (?),0x23 (?),0x24 (?),0x25 (?),0x26 (?),0x27 (?),0x28 (?),0x29 (?),0x2A (?),0x2B (?),0x2C (?),0x2D (?),0x2E (?),0x2F (?),0x30 (?),0x31 (?),0x32 (?),0x33 (?),0x34 (?),0x35 (?),0x36 (?),0x37 (?),0x38 (?),0x39 (?),0x3A (?),0x3B (?),0x3C (?),0x3D (?),0x3E (?),0x3F (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00583454$ PER_TESLA9X45_Part5.per -queue SNOC_EPRB1_SPROF_FILTERS_0_WINDOWSIZE"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00583460
tree " SNOC_EPRB1_SPROF_FILTERS_0_OPCODE [RW]                            0x00583460"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x0000000F    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_EPRB1_SPROF_FILTERS_0_OPCODE PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   3.           "[ 3 ]      URGEN                               = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   2.           "[ 2 ]      LOCKEN                              = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   1.           "[ 1 ]      WREN                                = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   0.           "[ 0 ]      RDEN                                = " "0x00 (?),0x01 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00583460$ PER_TESLA9X45_Part5.per -queue SNOC_EPRB1_SPROF_FILTERS_0_OPCODE"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00583464
tree " SNOC_EPRB1_SPROF_FILTERS_0_STATUS [RW]                            0x00583464"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x00000003    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_EPRB1_SPROF_FILTERS_0_STATUS PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   1.           "[ 1 ]      RSPEN                               = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   0.           "[ 0 ]      REQEN                               = " "0x00 (?),0x01 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00583464$ PER_TESLA9X45_Part5.per -queue SNOC_EPRB1_SPROF_FILTERS_0_STATUS"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00583468
tree " SNOC_EPRB1_SPROF_FILTERS_0_LENGTH [RW]                            0x00583468"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x0000000F    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_EPRB1_SPROF_FILTERS_0_LENGTH PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   0.--3.       "[3 : 0]    FILTERS_0_LENGTH                    = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?),0x08 (?),0x09 (?),0x0A (?),0x0B (?),0x0C (?),0x0D (?),0x0E (?),0x0F (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00583468$ PER_TESLA9X45_Part5.per -queue SNOC_EPRB1_SPROF_FILTERS_0_LENGTH"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0058346C
tree " SNOC_EPRB1_SPROF_FILTERS_0_URGENCY [RW]                           0x0058346C"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x00000003    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_EPRB1_SPROF_FILTERS_0_URGENCY PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   0.--1.       "[1 : 0]    FILTERS_0_URGENCY                   = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0058346C$ PER_TESLA9X45_Part5.per -queue SNOC_EPRB1_SPROF_FILTERS_0_URGENCY"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00583480
tree " SNOC_EPRB1_SPROF_FILTERS_1_ROUTEIDBASE [RW]                       0x00583480"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x1FFFFFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_EPRB1_SPROF_FILTERS_1_ROUTEIDBASE PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.long 0 0.--28. 1  "[28 : 0]   FILTERS_1_ROUTEIDBASE               = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00583480$ PER_TESLA9X45_Part5.per -queue SNOC_EPRB1_SPROF_FILTERS_1_ROUTEIDBASE"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00583484
tree " SNOC_EPRB1_SPROF_FILTERS_1_ROUTEIDMASK [RW]                       0x00583484"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x1FFFFFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_EPRB1_SPROF_FILTERS_1_ROUTEIDMASK PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.long 0 0.--28. 1  "[28 : 0]   FILTERS_1_ROUTEIDMASK               = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00583484$ PER_TESLA9X45_Part5.per -queue SNOC_EPRB1_SPROF_FILTERS_1_ROUTEIDMASK"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00583488
tree " SNOC_EPRB1_SPROF_FILTERS_1_ADDRBASE_LOW [RW]                      0x00583488"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0xFFFFFFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_EPRB1_SPROF_FILTERS_1_ADDRBASE_LOW PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.long 0 0.--31. 1  "[31 : 0]   FILTERS_1_ADDRBASE_LOW              = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00583488$ PER_TESLA9X45_Part5.per -queue SNOC_EPRB1_SPROF_FILTERS_1_ADDRBASE_LOW"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0058348C
tree " SNOC_EPRB1_SPROF_FILTERS_1_ADDRBASE_HIGH [RW]                     0x0058348C"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x00000001    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_EPRB1_SPROF_FILTERS_1_ADDRBASE_HIGH PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   0.           "[ 0 ]      FILTERS_1_ADDRBASE_HIGH             = " "0x00 (?),0x01 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0058348C$ PER_TESLA9X45_Part5.per -queue SNOC_EPRB1_SPROF_FILTERS_1_ADDRBASE_HIGH"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00583490
tree " SNOC_EPRB1_SPROF_FILTERS_1_WINDOWSIZE [RW]                        0x00583490"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x0000003F    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_EPRB1_SPROF_FILTERS_1_WINDOWSIZE PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   0.--5.       "[5 : 0]    FILTERS_1_WINDOWSIZE                = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?),0x08 (?),0x09 (?),0x0A (?),0x0B (?),0x0C (?),0x0D (?),0x0E (?),0x0F (?),0x10 (?),0x11 (?),0x12 (?),0x13 (?),0x14 (?),0x15 (?),0x16 (?),0x17 (?),0x18 (?),0x19 (?),0x1A (?),0x1B (?),0x1C (?),0x1D (?),0x1E (?),0x1F (?),0x20 (?),0x21 (?),0x22 (?),0x23 (?),0x24 (?),0x25 (?),0x26 (?),0x27 (?),0x28 (?),0x29 (?),0x2A (?),0x2B (?),0x2C (?),0x2D (?),0x2E (?),0x2F (?),0x30 (?),0x31 (?),0x32 (?),0x33 (?),0x34 (?),0x35 (?),0x36 (?),0x37 (?),0x38 (?),0x39 (?),0x3A (?),0x3B (?),0x3C (?),0x3D (?),0x3E (?),0x3F (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00583490$ PER_TESLA9X45_Part5.per -queue SNOC_EPRB1_SPROF_FILTERS_1_WINDOWSIZE"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0058349C
tree " SNOC_EPRB1_SPROF_FILTERS_1_OPCODE [RW]                            0x0058349C"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x0000000F    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_EPRB1_SPROF_FILTERS_1_OPCODE PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   3.           "[ 3 ]      URGEN                               = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   2.           "[ 2 ]      LOCKEN                              = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   1.           "[ 1 ]      WREN                                = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   0.           "[ 0 ]      RDEN                                = " "0x00 (?),0x01 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0058349C$ PER_TESLA9X45_Part5.per -queue SNOC_EPRB1_SPROF_FILTERS_1_OPCODE"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x005834A0
tree " SNOC_EPRB1_SPROF_FILTERS_1_STATUS [RW]                            0x005834A0"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x00000003    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_EPRB1_SPROF_FILTERS_1_STATUS PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   1.           "[ 1 ]      RSPEN                               = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   0.           "[ 0 ]      REQEN                               = " "0x00 (?),0x01 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x005834A0$ PER_TESLA9X45_Part5.per -queue SNOC_EPRB1_SPROF_FILTERS_1_STATUS"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x005834A4
tree " SNOC_EPRB1_SPROF_FILTERS_1_LENGTH [RW]                            0x005834A4"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x0000000F    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_EPRB1_SPROF_FILTERS_1_LENGTH PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   0.--3.       "[3 : 0]    FILTERS_1_LENGTH                    = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?),0x08 (?),0x09 (?),0x0A (?),0x0B (?),0x0C (?),0x0D (?),0x0E (?),0x0F (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x005834A4$ PER_TESLA9X45_Part5.per -queue SNOC_EPRB1_SPROF_FILTERS_1_LENGTH"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x005834A8
tree " SNOC_EPRB1_SPROF_FILTERS_1_URGENCY [RW]                           0x005834A8"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x00000003    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_EPRB1_SPROF_FILTERS_1_URGENCY PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   0.--1.       "[1 : 0]    FILTERS_1_URGENCY                   = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x005834A8$ PER_TESLA9X45_Part5.per -queue SNOC_EPRB1_SPROF_FILTERS_1_URGENCY"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x005834BC
tree " SNOC_EPRB1_SPROF_FILTERS_2_ROUTEIDBASE [RW]                       0x005834BC"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x1FFFFFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_EPRB1_SPROF_FILTERS_2_ROUTEIDBASE PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.long 0 0.--28. 1  "[28 : 0]   FILTERS_2_ROUTEIDBASE               = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x005834BC$ PER_TESLA9X45_Part5.per -queue SNOC_EPRB1_SPROF_FILTERS_2_ROUTEIDBASE"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x005834C0
tree " SNOC_EPRB1_SPROF_FILTERS_2_ROUTEIDMASK [RW]                       0x005834C0"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x1FFFFFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_EPRB1_SPROF_FILTERS_2_ROUTEIDMASK PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.long 0 0.--28. 1  "[28 : 0]   FILTERS_2_ROUTEIDMASK               = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x005834C0$ PER_TESLA9X45_Part5.per -queue SNOC_EPRB1_SPROF_FILTERS_2_ROUTEIDMASK"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x005834C4
tree " SNOC_EPRB1_SPROF_FILTERS_2_ADDRBASE_LOW [RW]                      0x005834C4"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0xFFFFFFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_EPRB1_SPROF_FILTERS_2_ADDRBASE_LOW PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.long 0 0.--31. 1  "[31 : 0]   FILTERS_2_ADDRBASE_LOW              = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x005834C4$ PER_TESLA9X45_Part5.per -queue SNOC_EPRB1_SPROF_FILTERS_2_ADDRBASE_LOW"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x005834C8
tree " SNOC_EPRB1_SPROF_FILTERS_2_ADDRBASE_HIGH [RW]                     0x005834C8"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x00000001    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_EPRB1_SPROF_FILTERS_2_ADDRBASE_HIGH PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   0.           "[ 0 ]      FILTERS_2_ADDRBASE_HIGH             = " "0x00 (?),0x01 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x005834C8$ PER_TESLA9X45_Part5.per -queue SNOC_EPRB1_SPROF_FILTERS_2_ADDRBASE_HIGH"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x005834CC
tree " SNOC_EPRB1_SPROF_FILTERS_2_WINDOWSIZE [RW]                        0x005834CC"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x0000003F    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_EPRB1_SPROF_FILTERS_2_WINDOWSIZE PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   0.--5.       "[5 : 0]    FILTERS_2_WINDOWSIZE                = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?),0x08 (?),0x09 (?),0x0A (?),0x0B (?),0x0C (?),0x0D (?),0x0E (?),0x0F (?),0x10 (?),0x11 (?),0x12 (?),0x13 (?),0x14 (?),0x15 (?),0x16 (?),0x17 (?),0x18 (?),0x19 (?),0x1A (?),0x1B (?),0x1C (?),0x1D (?),0x1E (?),0x1F (?),0x20 (?),0x21 (?),0x22 (?),0x23 (?),0x24 (?),0x25 (?),0x26 (?),0x27 (?),0x28 (?),0x29 (?),0x2A (?),0x2B (?),0x2C (?),0x2D (?),0x2E (?),0x2F (?),0x30 (?),0x31 (?),0x32 (?),0x33 (?),0x34 (?),0x35 (?),0x36 (?),0x37 (?),0x38 (?),0x39 (?),0x3A (?),0x3B (?),0x3C (?),0x3D (?),0x3E (?),0x3F (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x005834CC$ PER_TESLA9X45_Part5.per -queue SNOC_EPRB1_SPROF_FILTERS_2_WINDOWSIZE"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x005834D8
tree " SNOC_EPRB1_SPROF_FILTERS_2_OPCODE [RW]                            0x005834D8"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x0000000F    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_EPRB1_SPROF_FILTERS_2_OPCODE PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   3.           "[ 3 ]      URGEN                               = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   2.           "[ 2 ]      LOCKEN                              = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   1.           "[ 1 ]      WREN                                = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   0.           "[ 0 ]      RDEN                                = " "0x00 (?),0x01 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x005834D8$ PER_TESLA9X45_Part5.per -queue SNOC_EPRB1_SPROF_FILTERS_2_OPCODE"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x005834DC
tree " SNOC_EPRB1_SPROF_FILTERS_2_STATUS [RW]                            0x005834DC"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x00000003    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_EPRB1_SPROF_FILTERS_2_STATUS PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   1.           "[ 1 ]      RSPEN                               = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   0.           "[ 0 ]      REQEN                               = " "0x00 (?),0x01 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x005834DC$ PER_TESLA9X45_Part5.per -queue SNOC_EPRB1_SPROF_FILTERS_2_STATUS"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x005834E0
tree " SNOC_EPRB1_SPROF_FILTERS_2_LENGTH [RW]                            0x005834E0"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x0000000F    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_EPRB1_SPROF_FILTERS_2_LENGTH PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   0.--3.       "[3 : 0]    FILTERS_2_LENGTH                    = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?),0x08 (?),0x09 (?),0x0A (?),0x0B (?),0x0C (?),0x0D (?),0x0E (?),0x0F (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x005834E0$ PER_TESLA9X45_Part5.per -queue SNOC_EPRB1_SPROF_FILTERS_2_LENGTH"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x005834E4
tree " SNOC_EPRB1_SPROF_FILTERS_2_URGENCY [RW]                           0x005834E4"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x00000003    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_EPRB1_SPROF_FILTERS_2_URGENCY PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   0.--1.       "[1 : 0]    FILTERS_2_URGENCY                   = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x005834E4$ PER_TESLA9X45_Part5.per -queue SNOC_EPRB1_SPROF_FILTERS_2_URGENCY"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x005834F8
tree " SNOC_EPRB1_SPROF_FILTERS_3_ROUTEIDBASE [RW]                       0x005834F8"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x1FFFFFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_EPRB1_SPROF_FILTERS_3_ROUTEIDBASE PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.long 0 0.--28. 1  "[28 : 0]   FILTERS_3_ROUTEIDBASE               = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x005834F8$ PER_TESLA9X45_Part5.per -queue SNOC_EPRB1_SPROF_FILTERS_3_ROUTEIDBASE"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x005834FC
tree " SNOC_EPRB1_SPROF_FILTERS_3_ROUTEIDMASK [RW]                       0x005834FC"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x1FFFFFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_EPRB1_SPROF_FILTERS_3_ROUTEIDMASK PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.long 0 0.--28. 1  "[28 : 0]   FILTERS_3_ROUTEIDMASK               = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x005834FC$ PER_TESLA9X45_Part5.per -queue SNOC_EPRB1_SPROF_FILTERS_3_ROUTEIDMASK"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00583500
tree " SNOC_EPRB1_SPROF_FILTERS_3_ADDRBASE_LOW [RW]                      0x00583500"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0xFFFFFFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_EPRB1_SPROF_FILTERS_3_ADDRBASE_LOW PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.long 0 0.--31. 1  "[31 : 0]   FILTERS_3_ADDRBASE_LOW              = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00583500$ PER_TESLA9X45_Part5.per -queue SNOC_EPRB1_SPROF_FILTERS_3_ADDRBASE_LOW"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00583504
tree " SNOC_EPRB1_SPROF_FILTERS_3_ADDRBASE_HIGH [RW]                     0x00583504"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x00000001    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_EPRB1_SPROF_FILTERS_3_ADDRBASE_HIGH PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   0.           "[ 0 ]      FILTERS_3_ADDRBASE_HIGH             = " "0x00 (?),0x01 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00583504$ PER_TESLA9X45_Part5.per -queue SNOC_EPRB1_SPROF_FILTERS_3_ADDRBASE_HIGH"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00583508
tree " SNOC_EPRB1_SPROF_FILTERS_3_WINDOWSIZE [RW]                        0x00583508"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x0000003F    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_EPRB1_SPROF_FILTERS_3_WINDOWSIZE PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   0.--5.       "[5 : 0]    FILTERS_3_WINDOWSIZE                = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?),0x08 (?),0x09 (?),0x0A (?),0x0B (?),0x0C (?),0x0D (?),0x0E (?),0x0F (?),0x10 (?),0x11 (?),0x12 (?),0x13 (?),0x14 (?),0x15 (?),0x16 (?),0x17 (?),0x18 (?),0x19 (?),0x1A (?),0x1B (?),0x1C (?),0x1D (?),0x1E (?),0x1F (?),0x20 (?),0x21 (?),0x22 (?),0x23 (?),0x24 (?),0x25 (?),0x26 (?),0x27 (?),0x28 (?),0x29 (?),0x2A (?),0x2B (?),0x2C (?),0x2D (?),0x2E (?),0x2F (?),0x30 (?),0x31 (?),0x32 (?),0x33 (?),0x34 (?),0x35 (?),0x36 (?),0x37 (?),0x38 (?),0x39 (?),0x3A (?),0x3B (?),0x3C (?),0x3D (?),0x3E (?),0x3F (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00583508$ PER_TESLA9X45_Part5.per -queue SNOC_EPRB1_SPROF_FILTERS_3_WINDOWSIZE"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00583514
tree " SNOC_EPRB1_SPROF_FILTERS_3_OPCODE [RW]                            0x00583514"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x0000000F    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_EPRB1_SPROF_FILTERS_3_OPCODE PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   3.           "[ 3 ]      URGEN                               = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   2.           "[ 2 ]      LOCKEN                              = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   1.           "[ 1 ]      WREN                                = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   0.           "[ 0 ]      RDEN                                = " "0x00 (?),0x01 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00583514$ PER_TESLA9X45_Part5.per -queue SNOC_EPRB1_SPROF_FILTERS_3_OPCODE"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00583518
tree " SNOC_EPRB1_SPROF_FILTERS_3_STATUS [RW]                            0x00583518"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x00000003    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_EPRB1_SPROF_FILTERS_3_STATUS PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   1.           "[ 1 ]      RSPEN                               = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   0.           "[ 0 ]      REQEN                               = " "0x00 (?),0x01 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00583518$ PER_TESLA9X45_Part5.per -queue SNOC_EPRB1_SPROF_FILTERS_3_STATUS"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0058351C
tree " SNOC_EPRB1_SPROF_FILTERS_3_LENGTH [RW]                            0x0058351C"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x0000000F    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_EPRB1_SPROF_FILTERS_3_LENGTH PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   0.--3.       "[3 : 0]    FILTERS_3_LENGTH                    = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?),0x08 (?),0x09 (?),0x0A (?),0x0B (?),0x0C (?),0x0D (?),0x0E (?),0x0F (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0058351C$ PER_TESLA9X45_Part5.per -queue SNOC_EPRB1_SPROF_FILTERS_3_LENGTH"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00583520
tree " SNOC_EPRB1_SPROF_FILTERS_3_URGENCY [RW]                           0x00583520"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x00000003    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_EPRB1_SPROF_FILTERS_3_URGENCY PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   0.--1.       "[1 : 0]    FILTERS_3_URGENCY                   = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00583520$ PER_TESLA9X45_Part5.per -queue SNOC_EPRB1_SPROF_FILTERS_3_URGENCY"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00583534
tree " SNOC_EPRB1_SPROF_COUNTERS_0_PORTSEL [RW]                          0x00583534"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = undef         "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_EPRB1_SPROF_COUNTERS_0_PORTSEL PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   0.--1.       "[1 : 0]    COUNTERS_0_PORTSEL                  = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00583534$ PER_TESLA9X45_Part5.per -queue SNOC_EPRB1_SPROF_COUNTERS_0_PORTSEL"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00583538
tree " SNOC_EPRB1_SPROF_COUNTERS_0_SRC [RW]                              0x00583538"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x0000001F    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_EPRB1_SPROF_COUNTERS_0_SRC PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   0.--4.       "[4 : 0]    INTEVENT                            = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?),0x08 (?),0x09 (?),0x0A (?),0x0B (?),0x0C (?),0x0D (?),0x0E (?),0x0F (?),0x10 (?),0x11 (?),0x12 (?),0x13 (?),0x14 (?),0x15 (?),0x16 (?),0x17 (?),0x18 (?),0x19 (?),0x1A (?),0x1B (?),0x1C (?),0x1D (?),0x1E (?),0x1F (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00583538$ PER_TESLA9X45_Part5.per -queue SNOC_EPRB1_SPROF_COUNTERS_0_SRC"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0058353C
tree " SNOC_EPRB1_SPROF_COUNTERS_0_ALARMMODE [RW]                        0x0058353C"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x00000003    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_EPRB1_SPROF_COUNTERS_0_ALARMMODE PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   0.--1.       "[1 : 0]    COUNTERS_0_ALARMMODE                = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0058353C$ PER_TESLA9X45_Part5.per -queue SNOC_EPRB1_SPROF_COUNTERS_0_ALARMMODE"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00583540
tree " SNOC_EPRB1_SPROF_COUNTERS_0_VAL [R]                               0x00583540"
  group.long 0x0--0x3
   textline "POR 0xDEADBEEF [0xxxxxxxxx]    MASK =  "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_EPRB1_SPROF_COUNTERS_0_VAL PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.word 0 0.--15. 1  "[15 : 0]   COUNTERS_0_VAL                      = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00583540$ PER_TESLA9X45_Part5.per -queue SNOC_EPRB1_SPROF_COUNTERS_0_VAL"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00583548
tree " SNOC_EPRB1_SPROF_COUNTERS_1_PORTSEL [RW]                          0x00583548"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = undef         "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_EPRB1_SPROF_COUNTERS_1_PORTSEL PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   0.--1.       "[1 : 0]    COUNTERS_1_PORTSEL                  = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00583548$ PER_TESLA9X45_Part5.per -queue SNOC_EPRB1_SPROF_COUNTERS_1_PORTSEL"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0058354C
tree " SNOC_EPRB1_SPROF_COUNTERS_1_SRC [RW]                              0x0058354C"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x0000001F    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_EPRB1_SPROF_COUNTERS_1_SRC PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   0.--4.       "[4 : 0]    INTEVENT                            = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?),0x08 (?),0x09 (?),0x0A (?),0x0B (?),0x0C (?),0x0D (?),0x0E (?),0x0F (?),0x10 (?),0x11 (?),0x12 (?),0x13 (?),0x14 (?),0x15 (?),0x16 (?),0x17 (?),0x18 (?),0x19 (?),0x1A (?),0x1B (?),0x1C (?),0x1D (?),0x1E (?),0x1F (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0058354C$ PER_TESLA9X45_Part5.per -queue SNOC_EPRB1_SPROF_COUNTERS_1_SRC"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00583550
tree " SNOC_EPRB1_SPROF_COUNTERS_1_ALARMMODE [RW]                        0x00583550"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x00000003    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_EPRB1_SPROF_COUNTERS_1_ALARMMODE PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   0.--1.       "[1 : 0]    COUNTERS_1_ALARMMODE                = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00583550$ PER_TESLA9X45_Part5.per -queue SNOC_EPRB1_SPROF_COUNTERS_1_ALARMMODE"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00583554
tree " SNOC_EPRB1_SPROF_COUNTERS_1_VAL [R]                               0x00583554"
  group.long 0x0--0x3
   textline "POR 0xDEADBEEF [0xxxxxxxxx]    MASK =  "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_EPRB1_SPROF_COUNTERS_1_VAL PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.word 0 0.--15. 1  "[15 : 0]   COUNTERS_1_VAL                      = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00583554$ PER_TESLA9X45_Part5.per -queue SNOC_EPRB1_SPROF_COUNTERS_1_VAL"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0058355C
tree " SNOC_EPRB1_SPROF_COUNTERS_2_PORTSEL [RW]                          0x0058355C"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = undef         "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_EPRB1_SPROF_COUNTERS_2_PORTSEL PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   0.--1.       "[1 : 0]    COUNTERS_2_PORTSEL                  = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0058355C$ PER_TESLA9X45_Part5.per -queue SNOC_EPRB1_SPROF_COUNTERS_2_PORTSEL"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00583560
tree " SNOC_EPRB1_SPROF_COUNTERS_2_SRC [RW]                              0x00583560"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x0000001F    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_EPRB1_SPROF_COUNTERS_2_SRC PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   0.--4.       "[4 : 0]    INTEVENT                            = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?),0x08 (?),0x09 (?),0x0A (?),0x0B (?),0x0C (?),0x0D (?),0x0E (?),0x0F (?),0x10 (?),0x11 (?),0x12 (?),0x13 (?),0x14 (?),0x15 (?),0x16 (?),0x17 (?),0x18 (?),0x19 (?),0x1A (?),0x1B (?),0x1C (?),0x1D (?),0x1E (?),0x1F (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00583560$ PER_TESLA9X45_Part5.per -queue SNOC_EPRB1_SPROF_COUNTERS_2_SRC"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00583564
tree " SNOC_EPRB1_SPROF_COUNTERS_2_ALARMMODE [RW]                        0x00583564"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x00000003    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_EPRB1_SPROF_COUNTERS_2_ALARMMODE PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   0.--1.       "[1 : 0]    COUNTERS_2_ALARMMODE                = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00583564$ PER_TESLA9X45_Part5.per -queue SNOC_EPRB1_SPROF_COUNTERS_2_ALARMMODE"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00583568
tree " SNOC_EPRB1_SPROF_COUNTERS_2_VAL [R]                               0x00583568"
  group.long 0x0--0x3
   textline "POR 0xDEADBEEF [0xxxxxxxxx]    MASK =  "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_EPRB1_SPROF_COUNTERS_2_VAL PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.word 0 0.--15. 1  "[15 : 0]   COUNTERS_2_VAL                      = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00583568$ PER_TESLA9X45_Part5.per -queue SNOC_EPRB1_SPROF_COUNTERS_2_VAL"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00583570
tree " SNOC_EPRB1_SPROF_COUNTERS_3_PORTSEL [RW]                          0x00583570"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = undef         "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_EPRB1_SPROF_COUNTERS_3_PORTSEL PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   0.--1.       "[1 : 0]    COUNTERS_3_PORTSEL                  = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00583570$ PER_TESLA9X45_Part5.per -queue SNOC_EPRB1_SPROF_COUNTERS_3_PORTSEL"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00583574
tree " SNOC_EPRB1_SPROF_COUNTERS_3_SRC [RW]                              0x00583574"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x0000001F    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_EPRB1_SPROF_COUNTERS_3_SRC PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   0.--4.       "[4 : 0]    INTEVENT                            = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?),0x08 (?),0x09 (?),0x0A (?),0x0B (?),0x0C (?),0x0D (?),0x0E (?),0x0F (?),0x10 (?),0x11 (?),0x12 (?),0x13 (?),0x14 (?),0x15 (?),0x16 (?),0x17 (?),0x18 (?),0x19 (?),0x1A (?),0x1B (?),0x1C (?),0x1D (?),0x1E (?),0x1F (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00583574$ PER_TESLA9X45_Part5.per -queue SNOC_EPRB1_SPROF_COUNTERS_3_SRC"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00583578
tree " SNOC_EPRB1_SPROF_COUNTERS_3_ALARMMODE [RW]                        0x00583578"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x00000003    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_EPRB1_SPROF_COUNTERS_3_ALARMMODE PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   0.--1.       "[1 : 0]    COUNTERS_3_ALARMMODE                = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00583578$ PER_TESLA9X45_Part5.per -queue SNOC_EPRB1_SPROF_COUNTERS_3_ALARMMODE"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0058357C
tree " SNOC_EPRB1_SPROF_COUNTERS_3_VAL [R]                               0x0058357C"
  group.long 0x0--0x3
   textline "POR 0xDEADBEEF [0xxxxxxxxx]    MASK =  "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_EPRB1_SPROF_COUNTERS_3_VAL PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.word 0 0.--15. 1  "[15 : 0]   COUNTERS_3_VAL                      = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0058357C$ PER_TESLA9X45_Part5.per -queue SNOC_EPRB1_SPROF_COUNTERS_3_VAL"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00583584
tree " SNOC_EPRB1_SPROF_COUNTERS_4_PORTSEL [RW]                          0x00583584"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = undef         "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_EPRB1_SPROF_COUNTERS_4_PORTSEL PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   0.--1.       "[1 : 0]    COUNTERS_4_PORTSEL                  = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00583584$ PER_TESLA9X45_Part5.per -queue SNOC_EPRB1_SPROF_COUNTERS_4_PORTSEL"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00583588
tree " SNOC_EPRB1_SPROF_COUNTERS_4_SRC [RW]                              0x00583588"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x0000001F    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_EPRB1_SPROF_COUNTERS_4_SRC PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   0.--4.       "[4 : 0]    INTEVENT                            = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?),0x08 (?),0x09 (?),0x0A (?),0x0B (?),0x0C (?),0x0D (?),0x0E (?),0x0F (?),0x10 (?),0x11 (?),0x12 (?),0x13 (?),0x14 (?),0x15 (?),0x16 (?),0x17 (?),0x18 (?),0x19 (?),0x1A (?),0x1B (?),0x1C (?),0x1D (?),0x1E (?),0x1F (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00583588$ PER_TESLA9X45_Part5.per -queue SNOC_EPRB1_SPROF_COUNTERS_4_SRC"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0058358C
tree " SNOC_EPRB1_SPROF_COUNTERS_4_ALARMMODE [RW]                        0x0058358C"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x00000003    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_EPRB1_SPROF_COUNTERS_4_ALARMMODE PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   0.--1.       "[1 : 0]    COUNTERS_4_ALARMMODE                = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0058358C$ PER_TESLA9X45_Part5.per -queue SNOC_EPRB1_SPROF_COUNTERS_4_ALARMMODE"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00583590
tree " SNOC_EPRB1_SPROF_COUNTERS_4_VAL [R]                               0x00583590"
  group.long 0x0--0x3
   textline "POR 0xDEADBEEF [0xxxxxxxxx]    MASK =  "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_EPRB1_SPROF_COUNTERS_4_VAL PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.word 0 0.--15. 1  "[15 : 0]   COUNTERS_4_VAL                      = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00583590$ PER_TESLA9X45_Part5.per -queue SNOC_EPRB1_SPROF_COUNTERS_4_VAL"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00583598
tree " SNOC_EPRB1_SPROF_COUNTERS_5_PORTSEL [RW]                          0x00583598"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = undef         "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_EPRB1_SPROF_COUNTERS_5_PORTSEL PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   0.--1.       "[1 : 0]    COUNTERS_5_PORTSEL                  = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00583598$ PER_TESLA9X45_Part5.per -queue SNOC_EPRB1_SPROF_COUNTERS_5_PORTSEL"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0058359C
tree " SNOC_EPRB1_SPROF_COUNTERS_5_SRC [RW]                              0x0058359C"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x0000001F    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_EPRB1_SPROF_COUNTERS_5_SRC PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   0.--4.       "[4 : 0]    INTEVENT                            = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?),0x08 (?),0x09 (?),0x0A (?),0x0B (?),0x0C (?),0x0D (?),0x0E (?),0x0F (?),0x10 (?),0x11 (?),0x12 (?),0x13 (?),0x14 (?),0x15 (?),0x16 (?),0x17 (?),0x18 (?),0x19 (?),0x1A (?),0x1B (?),0x1C (?),0x1D (?),0x1E (?),0x1F (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0058359C$ PER_TESLA9X45_Part5.per -queue SNOC_EPRB1_SPROF_COUNTERS_5_SRC"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x005835A0
tree " SNOC_EPRB1_SPROF_COUNTERS_5_ALARMMODE [RW]                        0x005835A0"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x00000003    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_EPRB1_SPROF_COUNTERS_5_ALARMMODE PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   0.--1.       "[1 : 0]    COUNTERS_5_ALARMMODE                = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x005835A0$ PER_TESLA9X45_Part5.per -queue SNOC_EPRB1_SPROF_COUNTERS_5_ALARMMODE"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x005835A4
tree " SNOC_EPRB1_SPROF_COUNTERS_5_VAL [R]                               0x005835A4"
  group.long 0x0--0x3
   textline "POR 0xDEADBEEF [0xxxxxxxxx]    MASK =  "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_EPRB1_SPROF_COUNTERS_5_VAL PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.word 0 0.--15. 1  "[15 : 0]   COUNTERS_5_VAL                      = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x005835A4$ PER_TESLA9X45_Part5.per -queue SNOC_EPRB1_SPROF_COUNTERS_5_VAL"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x005835AC
tree " SNOC_EPRB1_SPROF_COUNTERS_6_PORTSEL [RW]                          0x005835AC"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = undef         "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_EPRB1_SPROF_COUNTERS_6_PORTSEL PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   0.--1.       "[1 : 0]    COUNTERS_6_PORTSEL                  = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x005835AC$ PER_TESLA9X45_Part5.per -queue SNOC_EPRB1_SPROF_COUNTERS_6_PORTSEL"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x005835B0
tree " SNOC_EPRB1_SPROF_COUNTERS_6_SRC [RW]                              0x005835B0"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x0000001F    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_EPRB1_SPROF_COUNTERS_6_SRC PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   0.--4.       "[4 : 0]    INTEVENT                            = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?),0x08 (?),0x09 (?),0x0A (?),0x0B (?),0x0C (?),0x0D (?),0x0E (?),0x0F (?),0x10 (?),0x11 (?),0x12 (?),0x13 (?),0x14 (?),0x15 (?),0x16 (?),0x17 (?),0x18 (?),0x19 (?),0x1A (?),0x1B (?),0x1C (?),0x1D (?),0x1E (?),0x1F (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x005835B0$ PER_TESLA9X45_Part5.per -queue SNOC_EPRB1_SPROF_COUNTERS_6_SRC"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x005835B4
tree " SNOC_EPRB1_SPROF_COUNTERS_6_ALARMMODE [RW]                        0x005835B4"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x00000003    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_EPRB1_SPROF_COUNTERS_6_ALARMMODE PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   0.--1.       "[1 : 0]    COUNTERS_6_ALARMMODE                = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x005835B4$ PER_TESLA9X45_Part5.per -queue SNOC_EPRB1_SPROF_COUNTERS_6_ALARMMODE"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x005835B8
tree " SNOC_EPRB1_SPROF_COUNTERS_6_VAL [R]                               0x005835B8"
  group.long 0x0--0x3
   textline "POR 0xDEADBEEF [0xxxxxxxxx]    MASK =  "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_EPRB1_SPROF_COUNTERS_6_VAL PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.word 0 0.--15. 1  "[15 : 0]   COUNTERS_6_VAL                      = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x005835B8$ PER_TESLA9X45_Part5.per -queue SNOC_EPRB1_SPROF_COUNTERS_6_VAL"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x005835C0
tree " SNOC_EPRB1_SPROF_COUNTERS_7_PORTSEL [RW]                          0x005835C0"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = undef         "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_EPRB1_SPROF_COUNTERS_7_PORTSEL PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   0.--1.       "[1 : 0]    COUNTERS_7_PORTSEL                  = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x005835C0$ PER_TESLA9X45_Part5.per -queue SNOC_EPRB1_SPROF_COUNTERS_7_PORTSEL"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x005835C4
tree " SNOC_EPRB1_SPROF_COUNTERS_7_SRC [RW]                              0x005835C4"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x0000001F    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_EPRB1_SPROF_COUNTERS_7_SRC PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   0.--4.       "[4 : 0]    INTEVENT                            = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?),0x08 (?),0x09 (?),0x0A (?),0x0B (?),0x0C (?),0x0D (?),0x0E (?),0x0F (?),0x10 (?),0x11 (?),0x12 (?),0x13 (?),0x14 (?),0x15 (?),0x16 (?),0x17 (?),0x18 (?),0x19 (?),0x1A (?),0x1B (?),0x1C (?),0x1D (?),0x1E (?),0x1F (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x005835C4$ PER_TESLA9X45_Part5.per -queue SNOC_EPRB1_SPROF_COUNTERS_7_SRC"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x005835C8
tree " SNOC_EPRB1_SPROF_COUNTERS_7_ALARMMODE [RW]                        0x005835C8"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x00000003    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_EPRB1_SPROF_COUNTERS_7_ALARMMODE PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   0.--1.       "[1 : 0]    COUNTERS_7_ALARMMODE                = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x005835C8$ PER_TESLA9X45_Part5.per -queue SNOC_EPRB1_SPROF_COUNTERS_7_ALARMMODE"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x005835CC
tree " SNOC_EPRB1_SPROF_COUNTERS_7_VAL [R]                               0x005835CC"
  group.long 0x0--0x3
   textline "POR 0xDEADBEEF [0xxxxxxxxx]    MASK =  "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_EPRB1_SPROF_COUNTERS_7_VAL PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.word 0 0.--15. 1  "[15 : 0]   COUNTERS_7_VAL                      = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x005835CC$ PER_TESLA9X45_Part5.per -queue SNOC_EPRB1_SPROF_COUNTERS_7_VAL"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x005835D4
tree " SNOC_EPRB1_SPROF_COUNTERS_8_PORTSEL [RW]                          0x005835D4"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = undef         "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_EPRB1_SPROF_COUNTERS_8_PORTSEL PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   0.--1.       "[1 : 0]    COUNTERS_8_PORTSEL                  = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x005835D4$ PER_TESLA9X45_Part5.per -queue SNOC_EPRB1_SPROF_COUNTERS_8_PORTSEL"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x005835D8
tree " SNOC_EPRB1_SPROF_COUNTERS_8_SRC [RW]                              0x005835D8"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x0000001F    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_EPRB1_SPROF_COUNTERS_8_SRC PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   0.--4.       "[4 : 0]    INTEVENT                            = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?),0x08 (?),0x09 (?),0x0A (?),0x0B (?),0x0C (?),0x0D (?),0x0E (?),0x0F (?),0x10 (?),0x11 (?),0x12 (?),0x13 (?),0x14 (?),0x15 (?),0x16 (?),0x17 (?),0x18 (?),0x19 (?),0x1A (?),0x1B (?),0x1C (?),0x1D (?),0x1E (?),0x1F (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x005835D8$ PER_TESLA9X45_Part5.per -queue SNOC_EPRB1_SPROF_COUNTERS_8_SRC"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x005835DC
tree " SNOC_EPRB1_SPROF_COUNTERS_8_ALARMMODE [RW]                        0x005835DC"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x00000003    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_EPRB1_SPROF_COUNTERS_8_ALARMMODE PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   0.--1.       "[1 : 0]    COUNTERS_8_ALARMMODE                = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x005835DC$ PER_TESLA9X45_Part5.per -queue SNOC_EPRB1_SPROF_COUNTERS_8_ALARMMODE"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x005835E0
tree " SNOC_EPRB1_SPROF_COUNTERS_8_VAL [R]                               0x005835E0"
  group.long 0x0--0x3
   textline "POR 0xDEADBEEF [0xxxxxxxxx]    MASK =  "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_EPRB1_SPROF_COUNTERS_8_VAL PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.word 0 0.--15. 1  "[15 : 0]   COUNTERS_8_VAL                      = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x005835E0$ PER_TESLA9X45_Part5.per -queue SNOC_EPRB1_SPROF_COUNTERS_8_VAL"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x005835E8
tree " SNOC_EPRB1_SPROF_COUNTERS_9_PORTSEL [RW]                          0x005835E8"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = undef         "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_EPRB1_SPROF_COUNTERS_9_PORTSEL PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   0.--1.       "[1 : 0]    COUNTERS_9_PORTSEL                  = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x005835E8$ PER_TESLA9X45_Part5.per -queue SNOC_EPRB1_SPROF_COUNTERS_9_PORTSEL"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x005835EC
tree " SNOC_EPRB1_SPROF_COUNTERS_9_SRC [RW]                              0x005835EC"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x0000001F    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_EPRB1_SPROF_COUNTERS_9_SRC PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   0.--4.       "[4 : 0]    INTEVENT                            = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?),0x08 (?),0x09 (?),0x0A (?),0x0B (?),0x0C (?),0x0D (?),0x0E (?),0x0F (?),0x10 (?),0x11 (?),0x12 (?),0x13 (?),0x14 (?),0x15 (?),0x16 (?),0x17 (?),0x18 (?),0x19 (?),0x1A (?),0x1B (?),0x1C (?),0x1D (?),0x1E (?),0x1F (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x005835EC$ PER_TESLA9X45_Part5.per -queue SNOC_EPRB1_SPROF_COUNTERS_9_SRC"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x005835F0
tree " SNOC_EPRB1_SPROF_COUNTERS_9_ALARMMODE [RW]                        0x005835F0"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x00000003    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_EPRB1_SPROF_COUNTERS_9_ALARMMODE PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   0.--1.       "[1 : 0]    COUNTERS_9_ALARMMODE                = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x005835F0$ PER_TESLA9X45_Part5.per -queue SNOC_EPRB1_SPROF_COUNTERS_9_ALARMMODE"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x005835F4
tree " SNOC_EPRB1_SPROF_COUNTERS_9_VAL [R]                               0x005835F4"
  group.long 0x0--0x3
   textline "POR 0xDEADBEEF [0xxxxxxxxx]    MASK =  "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_EPRB1_SPROF_COUNTERS_9_VAL PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.word 0 0.--15. 1  "[15 : 0]   COUNTERS_9_VAL                      = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x005835F4$ PER_TESLA9X45_Part5.per -queue SNOC_EPRB1_SPROF_COUNTERS_9_VAL"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00584000
tree " SNOC_TPRB0_SPROF_ID_COREID [R]                                    0x00584000"
  group.long 0x0--0x3
   textline "POR 0x80A78306    MASK = 0xFFFFFFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_TPRB0_SPROF_ID_COREID PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.long 0 8.--31. 1  "[31 : 8]   CORECHECKSUM                        = "
   textline ""
   hexmask.long.byte 0 0.--7. 1   "[7 : 0]    CORETYPEID                          = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00584000$ PER_TESLA9X45_Part5.per -queue SNOC_TPRB0_SPROF_ID_COREID"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00584004
tree " SNOC_TPRB0_SPROF_ID_REVISIONID [R]                                0x00584004"
  group.long 0x0--0x3
   textline "POR 0x00049C00    MASK = 0xFFFFFFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_TPRB0_SPROF_ID_REVISIONID PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.long 0 8.--31. 1  "[31 : 8]   FLEXNOCID                           = "
   textline ""
   hexmask.long.byte 0 0.--7. 1   "[7 : 0]    USERID                              = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00584004$ PER_TESLA9X45_Part5.per -queue SNOC_TPRB0_SPROF_ID_REVISIONID"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00584008
tree " SNOC_TPRB0_SPROF_MAINCTL [RW]                                     0x00584008"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x000000FF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_TPRB0_SPROF_MAINCTL PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   7.           "[ 7 ]      FILTBYTEALWAYSCHAINABLEEN           = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   6.           "[ 6 ]      INTRUSIVEMODE                       = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   5.           "[ 5 ]      STATCONDDUMP                        = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   4.           "[ 4 ]      ALARMEN                             = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   3.           "[ 3 ]      STATEN                              = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   2.           "[ 2 ]      PAYLOADEN                           = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   1.           "[ 1 ]      TRACEEN                             = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   0.           "[ 0 ]      ERREN                               = " "0x00 (?),0x01 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00584008$ PER_TESLA9X45_Part5.per -queue SNOC_TPRB0_SPROF_MAINCTL"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0058400C
tree " SNOC_TPRB0_SPROF_CFGCTL [RW]                                      0x0058400C"
  group.long 0x0--0x3
   textline "POR 0xDEADBEEF [0xxxxxxxxx]    MASK =  "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_TPRB0_SPROF_CFGCTL PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   1.           "[ 1 ]      ACTIVE                              = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   0.           "[ 0 ]      GLOBALEN                            = " "0x00 (?),0x01 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0058400C$ PER_TESLA9X45_Part5.per -queue SNOC_TPRB0_SPROF_CFGCTL"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00584024
tree " SNOC_TPRB0_SPROF_STATPERIOD [RW]                                  0x00584024"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x0000001F    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_TPRB0_SPROF_STATPERIOD PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   0.--4.       "[4 : 0]    STATPERIOD                          = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?),0x08 (?),0x09 (?),0x0A (?),0x0B (?),0x0C (?),0x0D (?),0x0E (?),0x0F (?),0x10 (?),0x11 (?),0x12 (?),0x13 (?),0x14 (?),0x15 (?),0x16 (?),0x17 (?),0x18 (?),0x19 (?),0x1A (?),0x1B (?),0x1C (?),0x1D (?),0x1E (?),0x1F (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00584024$ PER_TESLA9X45_Part5.per -queue SNOC_TPRB0_SPROF_STATPERIOD"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00584028
tree " SNOC_TPRB0_SPROF_STATGO [RW]                                      0x00584028"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x00000001    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_TPRB0_SPROF_STATGO PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   0.           "[ 0 ]      STATGO                              = " "0x00 (?),0x01 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00584028$ PER_TESLA9X45_Part5.per -queue SNOC_TPRB0_SPROF_STATGO"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0058402C
tree " SNOC_TPRB0_SPROF_STATALARMMIN [RW]                                0x0058402C"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0xFFFFFFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_TPRB0_SPROF_STATALARMMIN PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.long 0 0.--31. 1  "[31 : 0]   STATALARMMIN                        = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0058402C$ PER_TESLA9X45_Part5.per -queue SNOC_TPRB0_SPROF_STATALARMMIN"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00584030
tree " SNOC_TPRB0_SPROF_STATALARMMAX [RW]                                0x00584030"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0xFFFFFFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_TPRB0_SPROF_STATALARMMAX PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.long 0 0.--31. 1  "[31 : 0]   STATALARMMAX                        = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00584030$ PER_TESLA9X45_Part5.per -queue SNOC_TPRB0_SPROF_STATALARMMAX"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00584034
tree " SNOC_TPRB0_SPROF_STATALARMSTATUS [R]                              0x00584034"
  group.long 0x0--0x3
   textline "POR 0xDEADBEEF [0xxxxxxxxx]    MASK =  "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_TPRB0_SPROF_STATALARMSTATUS PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   0.           "[ 0 ]      STATALARMSTATUS                     = " "0x00 (?),0x01 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00584034$ PER_TESLA9X45_Part5.per -queue SNOC_TPRB0_SPROF_STATALARMSTATUS"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00584038
tree " SNOC_TPRB0_SPROF_STATALARMCLR [RW]                                0x00584038"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x00000001    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_TPRB0_SPROF_STATALARMCLR PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   0.           "[ 0 ]      STATALARMCLR                        = " "0x00 (?),0x01 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00584038$ PER_TESLA9X45_Part5.per -queue SNOC_TPRB0_SPROF_STATALARMCLR"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00584138
tree " SNOC_TPRB0_SPROF_COUNTERS_0_SRC [RW]                              0x00584138"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x0000003F    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_TPRB0_SPROF_COUNTERS_0_SRC PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   5.           "[ 5 ]      EXTEVENT                            = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   0.--4.       "[4 : 0]    INTEVENT                            = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?),0x08 (?),0x09 (?),0x0A (?),0x0B (?),0x0C (?),0x0D (?),0x0E (?),0x0F (?),0x10 (?),0x11 (?),0x12 (?),0x13 (?),0x14 (?),0x15 (?),0x16 (?),0x17 (?),0x18 (?),0x19 (?),0x1A (?),0x1B (?),0x1C (?),0x1D (?),0x1E (?),0x1F (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00584138$ PER_TESLA9X45_Part5.per -queue SNOC_TPRB0_SPROF_COUNTERS_0_SRC"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0058413C
tree " SNOC_TPRB0_SPROF_COUNTERS_0_ALARMMODE [RW]                        0x0058413C"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x00000003    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_TPRB0_SPROF_COUNTERS_0_ALARMMODE PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   0.--1.       "[1 : 0]    COUNTERS_0_ALARMMODE                = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0058413C$ PER_TESLA9X45_Part5.per -queue SNOC_TPRB0_SPROF_COUNTERS_0_ALARMMODE"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00584140
tree " SNOC_TPRB0_SPROF_COUNTERS_0_VAL [R]                               0x00584140"
  group.long 0x0--0x3
   textline "POR 0xDEADBEEF [0xxxxxxxxx]    MASK =  "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_TPRB0_SPROF_COUNTERS_0_VAL PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.word 0 0.--15. 1  "[15 : 0]   COUNTERS_0_VAL                      = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00584140$ PER_TESLA9X45_Part5.per -queue SNOC_TPRB0_SPROF_COUNTERS_0_VAL"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0058414C
tree " SNOC_TPRB0_SPROF_COUNTERS_1_SRC [RW]                              0x0058414C"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x0000003F    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_TPRB0_SPROF_COUNTERS_1_SRC PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   5.           "[ 5 ]      EXTEVENT                            = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   0.--4.       "[4 : 0]    INTEVENT                            = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?),0x08 (?),0x09 (?),0x0A (?),0x0B (?),0x0C (?),0x0D (?),0x0E (?),0x0F (?),0x10 (?),0x11 (?),0x12 (?),0x13 (?),0x14 (?),0x15 (?),0x16 (?),0x17 (?),0x18 (?),0x19 (?),0x1A (?),0x1B (?),0x1C (?),0x1D (?),0x1E (?),0x1F (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0058414C$ PER_TESLA9X45_Part5.per -queue SNOC_TPRB0_SPROF_COUNTERS_1_SRC"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00584150
tree " SNOC_TPRB0_SPROF_COUNTERS_1_ALARMMODE [RW]                        0x00584150"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x00000003    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_TPRB0_SPROF_COUNTERS_1_ALARMMODE PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   0.--1.       "[1 : 0]    COUNTERS_1_ALARMMODE                = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00584150$ PER_TESLA9X45_Part5.per -queue SNOC_TPRB0_SPROF_COUNTERS_1_ALARMMODE"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00584154
tree " SNOC_TPRB0_SPROF_COUNTERS_1_VAL [R]                               0x00584154"
  group.long 0x0--0x3
   textline "POR 0xDEADBEEF [0xxxxxxxxx]    MASK =  "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_TPRB0_SPROF_COUNTERS_1_VAL PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.word 0 0.--15. 1  "[15 : 0]   COUNTERS_1_VAL                      = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00584154$ PER_TESLA9X45_Part5.per -queue SNOC_TPRB0_SPROF_COUNTERS_1_VAL"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00584160
tree " SNOC_TPRB0_SPROF_COUNTERS_2_SRC [RW]                              0x00584160"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x0000003F    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_TPRB0_SPROF_COUNTERS_2_SRC PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   5.           "[ 5 ]      EXTEVENT                            = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   0.--4.       "[4 : 0]    INTEVENT                            = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?),0x08 (?),0x09 (?),0x0A (?),0x0B (?),0x0C (?),0x0D (?),0x0E (?),0x0F (?),0x10 (?),0x11 (?),0x12 (?),0x13 (?),0x14 (?),0x15 (?),0x16 (?),0x17 (?),0x18 (?),0x19 (?),0x1A (?),0x1B (?),0x1C (?),0x1D (?),0x1E (?),0x1F (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00584160$ PER_TESLA9X45_Part5.per -queue SNOC_TPRB0_SPROF_COUNTERS_2_SRC"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00584164
tree " SNOC_TPRB0_SPROF_COUNTERS_2_ALARMMODE [RW]                        0x00584164"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x00000003    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_TPRB0_SPROF_COUNTERS_2_ALARMMODE PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   0.--1.       "[1 : 0]    COUNTERS_2_ALARMMODE                = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00584164$ PER_TESLA9X45_Part5.per -queue SNOC_TPRB0_SPROF_COUNTERS_2_ALARMMODE"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00584168
tree " SNOC_TPRB0_SPROF_COUNTERS_2_VAL [R]                               0x00584168"
  group.long 0x0--0x3
   textline "POR 0xDEADBEEF [0xxxxxxxxx]    MASK =  "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_TPRB0_SPROF_COUNTERS_2_VAL PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.word 0 0.--15. 1  "[15 : 0]   COUNTERS_2_VAL                      = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00584168$ PER_TESLA9X45_Part5.per -queue SNOC_TPRB0_SPROF_COUNTERS_2_VAL"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00584174
tree " SNOC_TPRB0_SPROF_COUNTERS_3_SRC [RW]                              0x00584174"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x0000003F    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_TPRB0_SPROF_COUNTERS_3_SRC PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   5.           "[ 5 ]      EXTEVENT                            = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   0.--4.       "[4 : 0]    INTEVENT                            = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?),0x08 (?),0x09 (?),0x0A (?),0x0B (?),0x0C (?),0x0D (?),0x0E (?),0x0F (?),0x10 (?),0x11 (?),0x12 (?),0x13 (?),0x14 (?),0x15 (?),0x16 (?),0x17 (?),0x18 (?),0x19 (?),0x1A (?),0x1B (?),0x1C (?),0x1D (?),0x1E (?),0x1F (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00584174$ PER_TESLA9X45_Part5.per -queue SNOC_TPRB0_SPROF_COUNTERS_3_SRC"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00584178
tree " SNOC_TPRB0_SPROF_COUNTERS_3_ALARMMODE [RW]                        0x00584178"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x00000003    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_TPRB0_SPROF_COUNTERS_3_ALARMMODE PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   0.--1.       "[1 : 0]    COUNTERS_3_ALARMMODE                = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00584178$ PER_TESLA9X45_Part5.per -queue SNOC_TPRB0_SPROF_COUNTERS_3_ALARMMODE"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0058417C
tree " SNOC_TPRB0_SPROF_COUNTERS_3_VAL [R]                               0x0058417C"
  group.long 0x0--0x3
   textline "POR 0xDEADBEEF [0xxxxxxxxx]    MASK =  "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_TPRB0_SPROF_COUNTERS_3_VAL PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.word 0 0.--15. 1  "[15 : 0]   COUNTERS_3_VAL                      = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0058417C$ PER_TESLA9X45_Part5.per -queue SNOC_TPRB0_SPROF_COUNTERS_3_VAL"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00584188
tree " SNOC_TPRB0_SPROF_COUNTERS_4_SRC [RW]                              0x00584188"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x0000003F    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_TPRB0_SPROF_COUNTERS_4_SRC PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   5.           "[ 5 ]      EXTEVENT                            = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   0.--4.       "[4 : 0]    INTEVENT                            = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?),0x08 (?),0x09 (?),0x0A (?),0x0B (?),0x0C (?),0x0D (?),0x0E (?),0x0F (?),0x10 (?),0x11 (?),0x12 (?),0x13 (?),0x14 (?),0x15 (?),0x16 (?),0x17 (?),0x18 (?),0x19 (?),0x1A (?),0x1B (?),0x1C (?),0x1D (?),0x1E (?),0x1F (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00584188$ PER_TESLA9X45_Part5.per -queue SNOC_TPRB0_SPROF_COUNTERS_4_SRC"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0058418C
tree " SNOC_TPRB0_SPROF_COUNTERS_4_ALARMMODE [RW]                        0x0058418C"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x00000003    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_TPRB0_SPROF_COUNTERS_4_ALARMMODE PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   0.--1.       "[1 : 0]    COUNTERS_4_ALARMMODE                = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0058418C$ PER_TESLA9X45_Part5.per -queue SNOC_TPRB0_SPROF_COUNTERS_4_ALARMMODE"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00584190
tree " SNOC_TPRB0_SPROF_COUNTERS_4_VAL [R]                               0x00584190"
  group.long 0x0--0x3
   textline "POR 0xDEADBEEF [0xxxxxxxxx]    MASK =  "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_TPRB0_SPROF_COUNTERS_4_VAL PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.word 0 0.--15. 1  "[15 : 0]   COUNTERS_4_VAL                      = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00584190$ PER_TESLA9X45_Part5.per -queue SNOC_TPRB0_SPROF_COUNTERS_4_VAL"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0058419C
tree " SNOC_TPRB0_SPROF_COUNTERS_5_SRC [RW]                              0x0058419C"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x0000003F    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_TPRB0_SPROF_COUNTERS_5_SRC PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   5.           "[ 5 ]      EXTEVENT                            = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   0.--4.       "[4 : 0]    INTEVENT                            = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?),0x08 (?),0x09 (?),0x0A (?),0x0B (?),0x0C (?),0x0D (?),0x0E (?),0x0F (?),0x10 (?),0x11 (?),0x12 (?),0x13 (?),0x14 (?),0x15 (?),0x16 (?),0x17 (?),0x18 (?),0x19 (?),0x1A (?),0x1B (?),0x1C (?),0x1D (?),0x1E (?),0x1F (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0058419C$ PER_TESLA9X45_Part5.per -queue SNOC_TPRB0_SPROF_COUNTERS_5_SRC"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x005841A0
tree " SNOC_TPRB0_SPROF_COUNTERS_5_ALARMMODE [RW]                        0x005841A0"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x00000003    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_TPRB0_SPROF_COUNTERS_5_ALARMMODE PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   0.--1.       "[1 : 0]    COUNTERS_5_ALARMMODE                = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x005841A0$ PER_TESLA9X45_Part5.per -queue SNOC_TPRB0_SPROF_COUNTERS_5_ALARMMODE"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x005841A4
tree " SNOC_TPRB0_SPROF_COUNTERS_5_VAL [R]                               0x005841A4"
  group.long 0x0--0x3
   textline "POR 0xDEADBEEF [0xxxxxxxxx]    MASK =  "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_TPRB0_SPROF_COUNTERS_5_VAL PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.word 0 0.--15. 1  "[15 : 0]   COUNTERS_5_VAL                      = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x005841A4$ PER_TESLA9X45_Part5.per -queue SNOC_TPRB0_SPROF_COUNTERS_5_VAL"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x005841B0
tree " SNOC_TPRB0_SPROF_COUNTERS_6_SRC [RW]                              0x005841B0"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x0000003F    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_TPRB0_SPROF_COUNTERS_6_SRC PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   5.           "[ 5 ]      EXTEVENT                            = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   0.--4.       "[4 : 0]    INTEVENT                            = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?),0x08 (?),0x09 (?),0x0A (?),0x0B (?),0x0C (?),0x0D (?),0x0E (?),0x0F (?),0x10 (?),0x11 (?),0x12 (?),0x13 (?),0x14 (?),0x15 (?),0x16 (?),0x17 (?),0x18 (?),0x19 (?),0x1A (?),0x1B (?),0x1C (?),0x1D (?),0x1E (?),0x1F (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x005841B0$ PER_TESLA9X45_Part5.per -queue SNOC_TPRB0_SPROF_COUNTERS_6_SRC"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x005841B4
tree " SNOC_TPRB0_SPROF_COUNTERS_6_ALARMMODE [RW]                        0x005841B4"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x00000003    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_TPRB0_SPROF_COUNTERS_6_ALARMMODE PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   0.--1.       "[1 : 0]    COUNTERS_6_ALARMMODE                = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x005841B4$ PER_TESLA9X45_Part5.per -queue SNOC_TPRB0_SPROF_COUNTERS_6_ALARMMODE"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x005841B8
tree " SNOC_TPRB0_SPROF_COUNTERS_6_VAL [R]                               0x005841B8"
  group.long 0x0--0x3
   textline "POR 0xDEADBEEF [0xxxxxxxxx]    MASK =  "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_TPRB0_SPROF_COUNTERS_6_VAL PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.word 0 0.--15. 1  "[15 : 0]   COUNTERS_6_VAL                      = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x005841B8$ PER_TESLA9X45_Part5.per -queue SNOC_TPRB0_SPROF_COUNTERS_6_VAL"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x005841C4
tree " SNOC_TPRB0_SPROF_COUNTERS_7_SRC [RW]                              0x005841C4"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x0000003F    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_TPRB0_SPROF_COUNTERS_7_SRC PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   5.           "[ 5 ]      EXTEVENT                            = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   0.--4.       "[4 : 0]    INTEVENT                            = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?),0x08 (?),0x09 (?),0x0A (?),0x0B (?),0x0C (?),0x0D (?),0x0E (?),0x0F (?),0x10 (?),0x11 (?),0x12 (?),0x13 (?),0x14 (?),0x15 (?),0x16 (?),0x17 (?),0x18 (?),0x19 (?),0x1A (?),0x1B (?),0x1C (?),0x1D (?),0x1E (?),0x1F (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x005841C4$ PER_TESLA9X45_Part5.per -queue SNOC_TPRB0_SPROF_COUNTERS_7_SRC"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x005841C8
tree " SNOC_TPRB0_SPROF_COUNTERS_7_ALARMMODE [RW]                        0x005841C8"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x00000003    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_TPRB0_SPROF_COUNTERS_7_ALARMMODE PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   0.--1.       "[1 : 0]    COUNTERS_7_ALARMMODE                = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x005841C8$ PER_TESLA9X45_Part5.per -queue SNOC_TPRB0_SPROF_COUNTERS_7_ALARMMODE"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x005841CC
tree " SNOC_TPRB0_SPROF_COUNTERS_7_VAL [R]                               0x005841CC"
  group.long 0x0--0x3
   textline "POR 0xDEADBEEF [0xxxxxxxxx]    MASK =  "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_TPRB0_SPROF_COUNTERS_7_VAL PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.word 0 0.--15. 1  "[15 : 0]   COUNTERS_7_VAL                      = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x005841CC$ PER_TESLA9X45_Part5.per -queue SNOC_TPRB0_SPROF_COUNTERS_7_VAL"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x005841D8
tree " SNOC_TPRB0_SPROF_COUNTERS_8_SRC [RW]                              0x005841D8"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x0000003F    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_TPRB0_SPROF_COUNTERS_8_SRC PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   5.           "[ 5 ]      EXTEVENT                            = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   0.--4.       "[4 : 0]    INTEVENT                            = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?),0x08 (?),0x09 (?),0x0A (?),0x0B (?),0x0C (?),0x0D (?),0x0E (?),0x0F (?),0x10 (?),0x11 (?),0x12 (?),0x13 (?),0x14 (?),0x15 (?),0x16 (?),0x17 (?),0x18 (?),0x19 (?),0x1A (?),0x1B (?),0x1C (?),0x1D (?),0x1E (?),0x1F (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x005841D8$ PER_TESLA9X45_Part5.per -queue SNOC_TPRB0_SPROF_COUNTERS_8_SRC"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x005841DC
tree " SNOC_TPRB0_SPROF_COUNTERS_8_ALARMMODE [RW]                        0x005841DC"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x00000003    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_TPRB0_SPROF_COUNTERS_8_ALARMMODE PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   0.--1.       "[1 : 0]    COUNTERS_8_ALARMMODE                = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x005841DC$ PER_TESLA9X45_Part5.per -queue SNOC_TPRB0_SPROF_COUNTERS_8_ALARMMODE"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x005841E0
tree " SNOC_TPRB0_SPROF_COUNTERS_8_VAL [R]                               0x005841E0"
  group.long 0x0--0x3
   textline "POR 0xDEADBEEF [0xxxxxxxxx]    MASK =  "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_TPRB0_SPROF_COUNTERS_8_VAL PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.word 0 0.--15. 1  "[15 : 0]   COUNTERS_8_VAL                      = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x005841E0$ PER_TESLA9X45_Part5.per -queue SNOC_TPRB0_SPROF_COUNTERS_8_VAL"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x005841EC
tree " SNOC_TPRB0_SPROF_COUNTERS_9_SRC [RW]                              0x005841EC"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x0000003F    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_TPRB0_SPROF_COUNTERS_9_SRC PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   5.           "[ 5 ]      EXTEVENT                            = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   0.--4.       "[4 : 0]    INTEVENT                            = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?),0x08 (?),0x09 (?),0x0A (?),0x0B (?),0x0C (?),0x0D (?),0x0E (?),0x0F (?),0x10 (?),0x11 (?),0x12 (?),0x13 (?),0x14 (?),0x15 (?),0x16 (?),0x17 (?),0x18 (?),0x19 (?),0x1A (?),0x1B (?),0x1C (?),0x1D (?),0x1E (?),0x1F (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x005841EC$ PER_TESLA9X45_Part5.per -queue SNOC_TPRB0_SPROF_COUNTERS_9_SRC"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x005841F0
tree " SNOC_TPRB0_SPROF_COUNTERS_9_ALARMMODE [RW]                        0x005841F0"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x00000003    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_TPRB0_SPROF_COUNTERS_9_ALARMMODE PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   0.--1.       "[1 : 0]    COUNTERS_9_ALARMMODE                = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x005841F0$ PER_TESLA9X45_Part5.per -queue SNOC_TPRB0_SPROF_COUNTERS_9_ALARMMODE"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x005841F4
tree " SNOC_TPRB0_SPROF_COUNTERS_9_VAL [R]                               0x005841F4"
  group.long 0x0--0x3
   textline "POR 0xDEADBEEF [0xxxxxxxxx]    MASK =  "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_TPRB0_SPROF_COUNTERS_9_VAL PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.word 0 0.--15. 1  "[15 : 0]   COUNTERS_9_VAL                      = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x005841F4$ PER_TESLA9X45_Part5.per -queue SNOC_TPRB0_SPROF_COUNTERS_9_VAL"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00584200
tree " SNOC_TPRB0_SPROF_COUNTERS_10_SRC [RW]                             0x00584200"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x0000003F    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_TPRB0_SPROF_COUNTERS_10_SRC PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   5.           "[ 5 ]      EXTEVENT                            = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   0.--4.       "[4 : 0]    INTEVENT                            = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?),0x08 (?),0x09 (?),0x0A (?),0x0B (?),0x0C (?),0x0D (?),0x0E (?),0x0F (?),0x10 (?),0x11 (?),0x12 (?),0x13 (?),0x14 (?),0x15 (?),0x16 (?),0x17 (?),0x18 (?),0x19 (?),0x1A (?),0x1B (?),0x1C (?),0x1D (?),0x1E (?),0x1F (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00584200$ PER_TESLA9X45_Part5.per -queue SNOC_TPRB0_SPROF_COUNTERS_10_SRC"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00584204
tree " SNOC_TPRB0_SPROF_COUNTERS_10_ALARMMODE [RW]                       0x00584204"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x00000003    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_TPRB0_SPROF_COUNTERS_10_ALARMMODE PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   0.--1.       "[1 : 0]    COUNTERS_10_ALARMMODE               = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00584204$ PER_TESLA9X45_Part5.per -queue SNOC_TPRB0_SPROF_COUNTERS_10_ALARMMODE"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00584208
tree " SNOC_TPRB0_SPROF_COUNTERS_10_VAL [R]                              0x00584208"
  group.long 0x0--0x3
   textline "POR 0xDEADBEEF [0xxxxxxxxx]    MASK =  "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_TPRB0_SPROF_COUNTERS_10_VAL PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.word 0 0.--15. 1  "[15 : 0]   COUNTERS_10_VAL                     = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00584208$ PER_TESLA9X45_Part5.per -queue SNOC_TPRB0_SPROF_COUNTERS_10_VAL"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00584214
tree " SNOC_TPRB0_SPROF_COUNTERS_11_SRC [RW]                             0x00584214"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x0000003F    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_TPRB0_SPROF_COUNTERS_11_SRC PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   5.           "[ 5 ]      EXTEVENT                            = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   0.--4.       "[4 : 0]    INTEVENT                            = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?),0x08 (?),0x09 (?),0x0A (?),0x0B (?),0x0C (?),0x0D (?),0x0E (?),0x0F (?),0x10 (?),0x11 (?),0x12 (?),0x13 (?),0x14 (?),0x15 (?),0x16 (?),0x17 (?),0x18 (?),0x19 (?),0x1A (?),0x1B (?),0x1C (?),0x1D (?),0x1E (?),0x1F (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00584214$ PER_TESLA9X45_Part5.per -queue SNOC_TPRB0_SPROF_COUNTERS_11_SRC"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00584218
tree " SNOC_TPRB0_SPROF_COUNTERS_11_ALARMMODE [RW]                       0x00584218"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x00000003    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_TPRB0_SPROF_COUNTERS_11_ALARMMODE PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   0.--1.       "[1 : 0]    COUNTERS_11_ALARMMODE               = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00584218$ PER_TESLA9X45_Part5.per -queue SNOC_TPRB0_SPROF_COUNTERS_11_ALARMMODE"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0058421C
tree " SNOC_TPRB0_SPROF_COUNTERS_11_VAL [R]                              0x0058421C"
  group.long 0x0--0x3
   textline "POR 0xDEADBEEF [0xxxxxxxxx]    MASK =  "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_TPRB0_SPROF_COUNTERS_11_VAL PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.word 0 0.--15. 1  "[15 : 0]   COUNTERS_11_VAL                     = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0058421C$ PER_TESLA9X45_Part5.per -queue SNOC_TPRB0_SPROF_COUNTERS_11_VAL"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00584228
tree " SNOC_TPRB0_SPROF_COUNTERS_12_SRC [RW]                             0x00584228"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x0000003F    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_TPRB0_SPROF_COUNTERS_12_SRC PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   5.           "[ 5 ]      EXTEVENT                            = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   0.--4.       "[4 : 0]    INTEVENT                            = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?),0x08 (?),0x09 (?),0x0A (?),0x0B (?),0x0C (?),0x0D (?),0x0E (?),0x0F (?),0x10 (?),0x11 (?),0x12 (?),0x13 (?),0x14 (?),0x15 (?),0x16 (?),0x17 (?),0x18 (?),0x19 (?),0x1A (?),0x1B (?),0x1C (?),0x1D (?),0x1E (?),0x1F (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00584228$ PER_TESLA9X45_Part5.per -queue SNOC_TPRB0_SPROF_COUNTERS_12_SRC"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0058422C
tree " SNOC_TPRB0_SPROF_COUNTERS_12_ALARMMODE [RW]                       0x0058422C"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x00000003    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_TPRB0_SPROF_COUNTERS_12_ALARMMODE PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   0.--1.       "[1 : 0]    COUNTERS_12_ALARMMODE               = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0058422C$ PER_TESLA9X45_Part5.per -queue SNOC_TPRB0_SPROF_COUNTERS_12_ALARMMODE"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00584230
tree " SNOC_TPRB0_SPROF_COUNTERS_12_VAL [R]                              0x00584230"
  group.long 0x0--0x3
   textline "POR 0xDEADBEEF [0xxxxxxxxx]    MASK =  "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_TPRB0_SPROF_COUNTERS_12_VAL PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.word 0 0.--15. 1  "[15 : 0]   COUNTERS_12_VAL                     = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00584230$ PER_TESLA9X45_Part5.per -queue SNOC_TPRB0_SPROF_COUNTERS_12_VAL"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0058423C
tree " SNOC_TPRB0_SPROF_COUNTERS_13_SRC [RW]                             0x0058423C"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x0000003F    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_TPRB0_SPROF_COUNTERS_13_SRC PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   5.           "[ 5 ]      EXTEVENT                            = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   0.--4.       "[4 : 0]    INTEVENT                            = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?),0x08 (?),0x09 (?),0x0A (?),0x0B (?),0x0C (?),0x0D (?),0x0E (?),0x0F (?),0x10 (?),0x11 (?),0x12 (?),0x13 (?),0x14 (?),0x15 (?),0x16 (?),0x17 (?),0x18 (?),0x19 (?),0x1A (?),0x1B (?),0x1C (?),0x1D (?),0x1E (?),0x1F (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0058423C$ PER_TESLA9X45_Part5.per -queue SNOC_TPRB0_SPROF_COUNTERS_13_SRC"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00584240
tree " SNOC_TPRB0_SPROF_COUNTERS_13_ALARMMODE [RW]                       0x00584240"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x00000003    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_TPRB0_SPROF_COUNTERS_13_ALARMMODE PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   0.--1.       "[1 : 0]    COUNTERS_13_ALARMMODE               = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00584240$ PER_TESLA9X45_Part5.per -queue SNOC_TPRB0_SPROF_COUNTERS_13_ALARMMODE"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00584244
tree " SNOC_TPRB0_SPROF_COUNTERS_13_VAL [R]                              0x00584244"
  group.long 0x0--0x3
   textline "POR 0xDEADBEEF [0xxxxxxxxx]    MASK =  "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_TPRB0_SPROF_COUNTERS_13_VAL PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.word 0 0.--15. 1  "[15 : 0]   COUNTERS_13_VAL                     = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00584244$ PER_TESLA9X45_Part5.per -queue SNOC_TPRB0_SPROF_COUNTERS_13_VAL"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00584250
tree " SNOC_TPRB0_SPROF_COUNTERS_14_SRC [RW]                             0x00584250"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x0000003F    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_TPRB0_SPROF_COUNTERS_14_SRC PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   5.           "[ 5 ]      EXTEVENT                            = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   0.--4.       "[4 : 0]    INTEVENT                            = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?),0x08 (?),0x09 (?),0x0A (?),0x0B (?),0x0C (?),0x0D (?),0x0E (?),0x0F (?),0x10 (?),0x11 (?),0x12 (?),0x13 (?),0x14 (?),0x15 (?),0x16 (?),0x17 (?),0x18 (?),0x19 (?),0x1A (?),0x1B (?),0x1C (?),0x1D (?),0x1E (?),0x1F (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00584250$ PER_TESLA9X45_Part5.per -queue SNOC_TPRB0_SPROF_COUNTERS_14_SRC"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00584254
tree " SNOC_TPRB0_SPROF_COUNTERS_14_ALARMMODE [RW]                       0x00584254"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x00000003    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_TPRB0_SPROF_COUNTERS_14_ALARMMODE PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   0.--1.       "[1 : 0]    COUNTERS_14_ALARMMODE               = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00584254$ PER_TESLA9X45_Part5.per -queue SNOC_TPRB0_SPROF_COUNTERS_14_ALARMMODE"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00584258
tree " SNOC_TPRB0_SPROF_COUNTERS_14_VAL [R]                              0x00584258"
  group.long 0x0--0x3
   textline "POR 0xDEADBEEF [0xxxxxxxxx]    MASK =  "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_TPRB0_SPROF_COUNTERS_14_VAL PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.word 0 0.--15. 1  "[15 : 0]   COUNTERS_14_VAL                     = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00584258$ PER_TESLA9X45_Part5.per -queue SNOC_TPRB0_SPROF_COUNTERS_14_VAL"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00584264
tree " SNOC_TPRB0_SPROF_COUNTERS_15_SRC [RW]                             0x00584264"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x0000003F    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_TPRB0_SPROF_COUNTERS_15_SRC PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   5.           "[ 5 ]      EXTEVENT                            = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   0.--4.       "[4 : 0]    INTEVENT                            = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?),0x08 (?),0x09 (?),0x0A (?),0x0B (?),0x0C (?),0x0D (?),0x0E (?),0x0F (?),0x10 (?),0x11 (?),0x12 (?),0x13 (?),0x14 (?),0x15 (?),0x16 (?),0x17 (?),0x18 (?),0x19 (?),0x1A (?),0x1B (?),0x1C (?),0x1D (?),0x1E (?),0x1F (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00584264$ PER_TESLA9X45_Part5.per -queue SNOC_TPRB0_SPROF_COUNTERS_15_SRC"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00584268
tree " SNOC_TPRB0_SPROF_COUNTERS_15_ALARMMODE [RW]                       0x00584268"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x00000003    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_TPRB0_SPROF_COUNTERS_15_ALARMMODE PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   0.--1.       "[1 : 0]    COUNTERS_15_ALARMMODE               = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00584268$ PER_TESLA9X45_Part5.per -queue SNOC_TPRB0_SPROF_COUNTERS_15_ALARMMODE"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0058426C
tree " SNOC_TPRB0_SPROF_COUNTERS_15_VAL [R]                              0x0058426C"
  group.long 0x0--0x3
   textline "POR 0xDEADBEEF [0xxxxxxxxx]    MASK =  "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_TPRB0_SPROF_COUNTERS_15_VAL PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.word 0 0.--15. 1  "[15 : 0]   COUNTERS_15_VAL                     = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0058426C$ PER_TESLA9X45_Part5.per -queue SNOC_TPRB0_SPROF_COUNTERS_15_VAL"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00584400
tree " SNOC_TPRB1_SPROF_ID_COREID [R]                                    0x00584400"
  group.long 0x0--0x3
   textline "POR 0xCF84B806    MASK = 0xFFFFFFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_TPRB1_SPROF_ID_COREID PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.long 0 8.--31. 1  "[31 : 8]   CORECHECKSUM                        = "
   textline ""
   hexmask.long.byte 0 0.--7. 1   "[7 : 0]    CORETYPEID                          = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00584400$ PER_TESLA9X45_Part5.per -queue SNOC_TPRB1_SPROF_ID_COREID"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00584404
tree " SNOC_TPRB1_SPROF_ID_REVISIONID [R]                                0x00584404"
  group.long 0x0--0x3
   textline "POR 0x00049C00    MASK = 0xFFFFFFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_TPRB1_SPROF_ID_REVISIONID PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.long 0 8.--31. 1  "[31 : 8]   FLEXNOCID                           = "
   textline ""
   hexmask.long.byte 0 0.--7. 1   "[7 : 0]    USERID                              = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00584404$ PER_TESLA9X45_Part5.per -queue SNOC_TPRB1_SPROF_ID_REVISIONID"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00584408
tree " SNOC_TPRB1_SPROF_MAINCTL [RW]                                     0x00584408"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x000000FF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_TPRB1_SPROF_MAINCTL PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   7.           "[ 7 ]      FILTBYTEALWAYSCHAINABLEEN           = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   6.           "[ 6 ]      INTRUSIVEMODE                       = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   5.           "[ 5 ]      STATCONDDUMP                        = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   4.           "[ 4 ]      ALARMEN                             = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   3.           "[ 3 ]      STATEN                              = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   2.           "[ 2 ]      PAYLOADEN                           = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   1.           "[ 1 ]      TRACEEN                             = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   0.           "[ 0 ]      ERREN                               = " "0x00 (?),0x01 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00584408$ PER_TESLA9X45_Part5.per -queue SNOC_TPRB1_SPROF_MAINCTL"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0058440C
tree " SNOC_TPRB1_SPROF_CFGCTL [RW]                                      0x0058440C"
  group.long 0x0--0x3
   textline "POR 0xDEADBEEF [0xxxxxxxxx]    MASK =  "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_TPRB1_SPROF_CFGCTL PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   1.           "[ 1 ]      ACTIVE                              = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   0.           "[ 0 ]      GLOBALEN                            = " "0x00 (?),0x01 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0058440C$ PER_TESLA9X45_Part5.per -queue SNOC_TPRB1_SPROF_CFGCTL"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00584424
tree " SNOC_TPRB1_SPROF_STATPERIOD [RW]                                  0x00584424"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x0000001F    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_TPRB1_SPROF_STATPERIOD PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   0.--4.       "[4 : 0]    STATPERIOD                          = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?),0x08 (?),0x09 (?),0x0A (?),0x0B (?),0x0C (?),0x0D (?),0x0E (?),0x0F (?),0x10 (?),0x11 (?),0x12 (?),0x13 (?),0x14 (?),0x15 (?),0x16 (?),0x17 (?),0x18 (?),0x19 (?),0x1A (?),0x1B (?),0x1C (?),0x1D (?),0x1E (?),0x1F (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00584424$ PER_TESLA9X45_Part5.per -queue SNOC_TPRB1_SPROF_STATPERIOD"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00584428
tree " SNOC_TPRB1_SPROF_STATGO [RW]                                      0x00584428"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x00000001    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_TPRB1_SPROF_STATGO PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   0.           "[ 0 ]      STATGO                              = " "0x00 (?),0x01 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00584428$ PER_TESLA9X45_Part5.per -queue SNOC_TPRB1_SPROF_STATGO"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0058442C
tree " SNOC_TPRB1_SPROF_STATALARMMIN [RW]                                0x0058442C"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0xFFFFFFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_TPRB1_SPROF_STATALARMMIN PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.long 0 0.--31. 1  "[31 : 0]   STATALARMMIN                        = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0058442C$ PER_TESLA9X45_Part5.per -queue SNOC_TPRB1_SPROF_STATALARMMIN"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00584430
tree " SNOC_TPRB1_SPROF_STATALARMMAX [RW]                                0x00584430"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0xFFFFFFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_TPRB1_SPROF_STATALARMMAX PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.long 0 0.--31. 1  "[31 : 0]   STATALARMMAX                        = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00584430$ PER_TESLA9X45_Part5.per -queue SNOC_TPRB1_SPROF_STATALARMMAX"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00584434
tree " SNOC_TPRB1_SPROF_STATALARMSTATUS [R]                              0x00584434"
  group.long 0x0--0x3
   textline "POR 0xDEADBEEF [0xxxxxxxxx]    MASK =  "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_TPRB1_SPROF_STATALARMSTATUS PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   0.           "[ 0 ]      STATALARMSTATUS                     = " "0x00 (?),0x01 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00584434$ PER_TESLA9X45_Part5.per -queue SNOC_TPRB1_SPROF_STATALARMSTATUS"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00584438
tree " SNOC_TPRB1_SPROF_STATALARMCLR [RW]                                0x00584438"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x00000001    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_TPRB1_SPROF_STATALARMCLR PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   0.           "[ 0 ]      STATALARMCLR                        = " "0x00 (?),0x01 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00584438$ PER_TESLA9X45_Part5.per -queue SNOC_TPRB1_SPROF_STATALARMCLR"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00584538
tree " SNOC_TPRB1_SPROF_COUNTERS_0_SRC [RW]                              0x00584538"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x0000003F    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_TPRB1_SPROF_COUNTERS_0_SRC PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   5.           "[ 5 ]      EXTEVENT                            = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   0.--4.       "[4 : 0]    INTEVENT                            = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?),0x08 (?),0x09 (?),0x0A (?),0x0B (?),0x0C (?),0x0D (?),0x0E (?),0x0F (?),0x10 (?),0x11 (?),0x12 (?),0x13 (?),0x14 (?),0x15 (?),0x16 (?),0x17 (?),0x18 (?),0x19 (?),0x1A (?),0x1B (?),0x1C (?),0x1D (?),0x1E (?),0x1F (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00584538$ PER_TESLA9X45_Part5.per -queue SNOC_TPRB1_SPROF_COUNTERS_0_SRC"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0058453C
tree " SNOC_TPRB1_SPROF_COUNTERS_0_ALARMMODE [RW]                        0x0058453C"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x00000003    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_TPRB1_SPROF_COUNTERS_0_ALARMMODE PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   0.--1.       "[1 : 0]    COUNTERS_0_ALARMMODE                = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0058453C$ PER_TESLA9X45_Part5.per -queue SNOC_TPRB1_SPROF_COUNTERS_0_ALARMMODE"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00584540
tree " SNOC_TPRB1_SPROF_COUNTERS_0_VAL [R]                               0x00584540"
  group.long 0x0--0x3
   textline "POR 0xDEADBEEF [0xxxxxxxxx]    MASK =  "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_TPRB1_SPROF_COUNTERS_0_VAL PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.word 0 0.--15. 1  "[15 : 0]   COUNTERS_0_VAL                      = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00584540$ PER_TESLA9X45_Part5.per -queue SNOC_TPRB1_SPROF_COUNTERS_0_VAL"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0058454C
tree " SNOC_TPRB1_SPROF_COUNTERS_1_SRC [RW]                              0x0058454C"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x0000003F    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_TPRB1_SPROF_COUNTERS_1_SRC PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   5.           "[ 5 ]      EXTEVENT                            = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   0.--4.       "[4 : 0]    INTEVENT                            = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?),0x08 (?),0x09 (?),0x0A (?),0x0B (?),0x0C (?),0x0D (?),0x0E (?),0x0F (?),0x10 (?),0x11 (?),0x12 (?),0x13 (?),0x14 (?),0x15 (?),0x16 (?),0x17 (?),0x18 (?),0x19 (?),0x1A (?),0x1B (?),0x1C (?),0x1D (?),0x1E (?),0x1F (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0058454C$ PER_TESLA9X45_Part5.per -queue SNOC_TPRB1_SPROF_COUNTERS_1_SRC"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00584550
tree " SNOC_TPRB1_SPROF_COUNTERS_1_ALARMMODE [RW]                        0x00584550"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x00000003    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_TPRB1_SPROF_COUNTERS_1_ALARMMODE PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   0.--1.       "[1 : 0]    COUNTERS_1_ALARMMODE                = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00584550$ PER_TESLA9X45_Part5.per -queue SNOC_TPRB1_SPROF_COUNTERS_1_ALARMMODE"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00584554
tree " SNOC_TPRB1_SPROF_COUNTERS_1_VAL [R]                               0x00584554"
  group.long 0x0--0x3
   textline "POR 0xDEADBEEF [0xxxxxxxxx]    MASK =  "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_TPRB1_SPROF_COUNTERS_1_VAL PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.word 0 0.--15. 1  "[15 : 0]   COUNTERS_1_VAL                      = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00584554$ PER_TESLA9X45_Part5.per -queue SNOC_TPRB1_SPROF_COUNTERS_1_VAL"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00584560
tree " SNOC_TPRB1_SPROF_COUNTERS_2_SRC [RW]                              0x00584560"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x0000003F    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_TPRB1_SPROF_COUNTERS_2_SRC PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   5.           "[ 5 ]      EXTEVENT                            = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   0.--4.       "[4 : 0]    INTEVENT                            = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?),0x08 (?),0x09 (?),0x0A (?),0x0B (?),0x0C (?),0x0D (?),0x0E (?),0x0F (?),0x10 (?),0x11 (?),0x12 (?),0x13 (?),0x14 (?),0x15 (?),0x16 (?),0x17 (?),0x18 (?),0x19 (?),0x1A (?),0x1B (?),0x1C (?),0x1D (?),0x1E (?),0x1F (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00584560$ PER_TESLA9X45_Part5.per -queue SNOC_TPRB1_SPROF_COUNTERS_2_SRC"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00584564
tree " SNOC_TPRB1_SPROF_COUNTERS_2_ALARMMODE [RW]                        0x00584564"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x00000003    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_TPRB1_SPROF_COUNTERS_2_ALARMMODE PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   0.--1.       "[1 : 0]    COUNTERS_2_ALARMMODE                = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00584564$ PER_TESLA9X45_Part5.per -queue SNOC_TPRB1_SPROF_COUNTERS_2_ALARMMODE"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00584568
tree " SNOC_TPRB1_SPROF_COUNTERS_2_VAL [R]                               0x00584568"
  group.long 0x0--0x3
   textline "POR 0xDEADBEEF [0xxxxxxxxx]    MASK =  "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_TPRB1_SPROF_COUNTERS_2_VAL PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.word 0 0.--15. 1  "[15 : 0]   COUNTERS_2_VAL                      = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00584568$ PER_TESLA9X45_Part5.per -queue SNOC_TPRB1_SPROF_COUNTERS_2_VAL"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00584574
tree " SNOC_TPRB1_SPROF_COUNTERS_3_SRC [RW]                              0x00584574"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x0000003F    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_TPRB1_SPROF_COUNTERS_3_SRC PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   5.           "[ 5 ]      EXTEVENT                            = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   0.--4.       "[4 : 0]    INTEVENT                            = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?),0x08 (?),0x09 (?),0x0A (?),0x0B (?),0x0C (?),0x0D (?),0x0E (?),0x0F (?),0x10 (?),0x11 (?),0x12 (?),0x13 (?),0x14 (?),0x15 (?),0x16 (?),0x17 (?),0x18 (?),0x19 (?),0x1A (?),0x1B (?),0x1C (?),0x1D (?),0x1E (?),0x1F (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00584574$ PER_TESLA9X45_Part5.per -queue SNOC_TPRB1_SPROF_COUNTERS_3_SRC"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00584578
tree " SNOC_TPRB1_SPROF_COUNTERS_3_ALARMMODE [RW]                        0x00584578"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x00000003    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_TPRB1_SPROF_COUNTERS_3_ALARMMODE PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   0.--1.       "[1 : 0]    COUNTERS_3_ALARMMODE                = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00584578$ PER_TESLA9X45_Part5.per -queue SNOC_TPRB1_SPROF_COUNTERS_3_ALARMMODE"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0058457C
tree " SNOC_TPRB1_SPROF_COUNTERS_3_VAL [R]                               0x0058457C"
  group.long 0x0--0x3
   textline "POR 0xDEADBEEF [0xxxxxxxxx]    MASK =  "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_TPRB1_SPROF_COUNTERS_3_VAL PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.word 0 0.--15. 1  "[15 : 0]   COUNTERS_3_VAL                      = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0058457C$ PER_TESLA9X45_Part5.per -queue SNOC_TPRB1_SPROF_COUNTERS_3_VAL"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00584588
tree " SNOC_TPRB1_SPROF_COUNTERS_4_SRC [RW]                              0x00584588"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x0000003F    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_TPRB1_SPROF_COUNTERS_4_SRC PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   5.           "[ 5 ]      EXTEVENT                            = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   0.--4.       "[4 : 0]    INTEVENT                            = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?),0x08 (?),0x09 (?),0x0A (?),0x0B (?),0x0C (?),0x0D (?),0x0E (?),0x0F (?),0x10 (?),0x11 (?),0x12 (?),0x13 (?),0x14 (?),0x15 (?),0x16 (?),0x17 (?),0x18 (?),0x19 (?),0x1A (?),0x1B (?),0x1C (?),0x1D (?),0x1E (?),0x1F (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00584588$ PER_TESLA9X45_Part5.per -queue SNOC_TPRB1_SPROF_COUNTERS_4_SRC"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0058458C
tree " SNOC_TPRB1_SPROF_COUNTERS_4_ALARMMODE [RW]                        0x0058458C"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x00000003    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_TPRB1_SPROF_COUNTERS_4_ALARMMODE PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   0.--1.       "[1 : 0]    COUNTERS_4_ALARMMODE                = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0058458C$ PER_TESLA9X45_Part5.per -queue SNOC_TPRB1_SPROF_COUNTERS_4_ALARMMODE"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00584590
tree " SNOC_TPRB1_SPROF_COUNTERS_4_VAL [R]                               0x00584590"
  group.long 0x0--0x3
   textline "POR 0xDEADBEEF [0xxxxxxxxx]    MASK =  "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_TPRB1_SPROF_COUNTERS_4_VAL PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.word 0 0.--15. 1  "[15 : 0]   COUNTERS_4_VAL                      = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00584590$ PER_TESLA9X45_Part5.per -queue SNOC_TPRB1_SPROF_COUNTERS_4_VAL"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0058459C
tree " SNOC_TPRB1_SPROF_COUNTERS_5_SRC [RW]                              0x0058459C"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x0000003F    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_TPRB1_SPROF_COUNTERS_5_SRC PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   5.           "[ 5 ]      EXTEVENT                            = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   0.--4.       "[4 : 0]    INTEVENT                            = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?),0x08 (?),0x09 (?),0x0A (?),0x0B (?),0x0C (?),0x0D (?),0x0E (?),0x0F (?),0x10 (?),0x11 (?),0x12 (?),0x13 (?),0x14 (?),0x15 (?),0x16 (?),0x17 (?),0x18 (?),0x19 (?),0x1A (?),0x1B (?),0x1C (?),0x1D (?),0x1E (?),0x1F (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0058459C$ PER_TESLA9X45_Part5.per -queue SNOC_TPRB1_SPROF_COUNTERS_5_SRC"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x005845A0
tree " SNOC_TPRB1_SPROF_COUNTERS_5_ALARMMODE [RW]                        0x005845A0"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x00000003    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_TPRB1_SPROF_COUNTERS_5_ALARMMODE PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   0.--1.       "[1 : 0]    COUNTERS_5_ALARMMODE                = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x005845A0$ PER_TESLA9X45_Part5.per -queue SNOC_TPRB1_SPROF_COUNTERS_5_ALARMMODE"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x005845A4
tree " SNOC_TPRB1_SPROF_COUNTERS_5_VAL [R]                               0x005845A4"
  group.long 0x0--0x3
   textline "POR 0xDEADBEEF [0xxxxxxxxx]    MASK =  "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_TPRB1_SPROF_COUNTERS_5_VAL PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.word 0 0.--15. 1  "[15 : 0]   COUNTERS_5_VAL                      = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x005845A4$ PER_TESLA9X45_Part5.per -queue SNOC_TPRB1_SPROF_COUNTERS_5_VAL"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x005845B0
tree " SNOC_TPRB1_SPROF_COUNTERS_6_SRC [RW]                              0x005845B0"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x0000003F    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_TPRB1_SPROF_COUNTERS_6_SRC PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   5.           "[ 5 ]      EXTEVENT                            = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   0.--4.       "[4 : 0]    INTEVENT                            = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?),0x08 (?),0x09 (?),0x0A (?),0x0B (?),0x0C (?),0x0D (?),0x0E (?),0x0F (?),0x10 (?),0x11 (?),0x12 (?),0x13 (?),0x14 (?),0x15 (?),0x16 (?),0x17 (?),0x18 (?),0x19 (?),0x1A (?),0x1B (?),0x1C (?),0x1D (?),0x1E (?),0x1F (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x005845B0$ PER_TESLA9X45_Part5.per -queue SNOC_TPRB1_SPROF_COUNTERS_6_SRC"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x005845B4
tree " SNOC_TPRB1_SPROF_COUNTERS_6_ALARMMODE [RW]                        0x005845B4"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x00000003    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_TPRB1_SPROF_COUNTERS_6_ALARMMODE PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   0.--1.       "[1 : 0]    COUNTERS_6_ALARMMODE                = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x005845B4$ PER_TESLA9X45_Part5.per -queue SNOC_TPRB1_SPROF_COUNTERS_6_ALARMMODE"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x005845B8
tree " SNOC_TPRB1_SPROF_COUNTERS_6_VAL [R]                               0x005845B8"
  group.long 0x0--0x3
   textline "POR 0xDEADBEEF [0xxxxxxxxx]    MASK =  "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_TPRB1_SPROF_COUNTERS_6_VAL PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.word 0 0.--15. 1  "[15 : 0]   COUNTERS_6_VAL                      = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x005845B8$ PER_TESLA9X45_Part5.per -queue SNOC_TPRB1_SPROF_COUNTERS_6_VAL"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x005845C4
tree " SNOC_TPRB1_SPROF_COUNTERS_7_SRC [RW]                              0x005845C4"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x0000003F    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_TPRB1_SPROF_COUNTERS_7_SRC PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   5.           "[ 5 ]      EXTEVENT                            = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   0.--4.       "[4 : 0]    INTEVENT                            = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?),0x08 (?),0x09 (?),0x0A (?),0x0B (?),0x0C (?),0x0D (?),0x0E (?),0x0F (?),0x10 (?),0x11 (?),0x12 (?),0x13 (?),0x14 (?),0x15 (?),0x16 (?),0x17 (?),0x18 (?),0x19 (?),0x1A (?),0x1B (?),0x1C (?),0x1D (?),0x1E (?),0x1F (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x005845C4$ PER_TESLA9X45_Part5.per -queue SNOC_TPRB1_SPROF_COUNTERS_7_SRC"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x005845C8
tree " SNOC_TPRB1_SPROF_COUNTERS_7_ALARMMODE [RW]                        0x005845C8"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x00000003    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_TPRB1_SPROF_COUNTERS_7_ALARMMODE PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   0.--1.       "[1 : 0]    COUNTERS_7_ALARMMODE                = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x005845C8$ PER_TESLA9X45_Part5.per -queue SNOC_TPRB1_SPROF_COUNTERS_7_ALARMMODE"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x005845CC
tree " SNOC_TPRB1_SPROF_COUNTERS_7_VAL [R]                               0x005845CC"
  group.long 0x0--0x3
   textline "POR 0xDEADBEEF [0xxxxxxxxx]    MASK =  "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_TPRB1_SPROF_COUNTERS_7_VAL PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.word 0 0.--15. 1  "[15 : 0]   COUNTERS_7_VAL                      = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x005845CC$ PER_TESLA9X45_Part5.per -queue SNOC_TPRB1_SPROF_COUNTERS_7_VAL"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x005845D8
tree " SNOC_TPRB1_SPROF_COUNTERS_8_SRC [RW]                              0x005845D8"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x0000003F    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_TPRB1_SPROF_COUNTERS_8_SRC PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   5.           "[ 5 ]      EXTEVENT                            = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   0.--4.       "[4 : 0]    INTEVENT                            = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?),0x08 (?),0x09 (?),0x0A (?),0x0B (?),0x0C (?),0x0D (?),0x0E (?),0x0F (?),0x10 (?),0x11 (?),0x12 (?),0x13 (?),0x14 (?),0x15 (?),0x16 (?),0x17 (?),0x18 (?),0x19 (?),0x1A (?),0x1B (?),0x1C (?),0x1D (?),0x1E (?),0x1F (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x005845D8$ PER_TESLA9X45_Part5.per -queue SNOC_TPRB1_SPROF_COUNTERS_8_SRC"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x005845DC
tree " SNOC_TPRB1_SPROF_COUNTERS_8_ALARMMODE [RW]                        0x005845DC"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x00000003    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_TPRB1_SPROF_COUNTERS_8_ALARMMODE PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   0.--1.       "[1 : 0]    COUNTERS_8_ALARMMODE                = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x005845DC$ PER_TESLA9X45_Part5.per -queue SNOC_TPRB1_SPROF_COUNTERS_8_ALARMMODE"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x005845E0
tree " SNOC_TPRB1_SPROF_COUNTERS_8_VAL [R]                               0x005845E0"
  group.long 0x0--0x3
   textline "POR 0xDEADBEEF [0xxxxxxxxx]    MASK =  "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_TPRB1_SPROF_COUNTERS_8_VAL PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.word 0 0.--15. 1  "[15 : 0]   COUNTERS_8_VAL                      = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x005845E0$ PER_TESLA9X45_Part5.per -queue SNOC_TPRB1_SPROF_COUNTERS_8_VAL"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x005845EC
tree " SNOC_TPRB1_SPROF_COUNTERS_9_SRC [RW]                              0x005845EC"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x0000003F    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_TPRB1_SPROF_COUNTERS_9_SRC PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   5.           "[ 5 ]      EXTEVENT                            = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   0.--4.       "[4 : 0]    INTEVENT                            = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?),0x08 (?),0x09 (?),0x0A (?),0x0B (?),0x0C (?),0x0D (?),0x0E (?),0x0F (?),0x10 (?),0x11 (?),0x12 (?),0x13 (?),0x14 (?),0x15 (?),0x16 (?),0x17 (?),0x18 (?),0x19 (?),0x1A (?),0x1B (?),0x1C (?),0x1D (?),0x1E (?),0x1F (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x005845EC$ PER_TESLA9X45_Part5.per -queue SNOC_TPRB1_SPROF_COUNTERS_9_SRC"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x005845F0
tree " SNOC_TPRB1_SPROF_COUNTERS_9_ALARMMODE [RW]                        0x005845F0"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x00000003    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_TPRB1_SPROF_COUNTERS_9_ALARMMODE PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   0.--1.       "[1 : 0]    COUNTERS_9_ALARMMODE                = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x005845F0$ PER_TESLA9X45_Part5.per -queue SNOC_TPRB1_SPROF_COUNTERS_9_ALARMMODE"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x005845F4
tree " SNOC_TPRB1_SPROF_COUNTERS_9_VAL [R]                               0x005845F4"
  group.long 0x0--0x3
   textline "POR 0xDEADBEEF [0xxxxxxxxx]    MASK =  "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_TPRB1_SPROF_COUNTERS_9_VAL PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.word 0 0.--15. 1  "[15 : 0]   COUNTERS_9_VAL                      = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x005845F4$ PER_TESLA9X45_Part5.per -queue SNOC_TPRB1_SPROF_COUNTERS_9_VAL"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00584600
tree " SNOC_TPRB1_SPROF_COUNTERS_10_SRC [RW]                             0x00584600"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x0000003F    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_TPRB1_SPROF_COUNTERS_10_SRC PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   5.           "[ 5 ]      EXTEVENT                            = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   0.--4.       "[4 : 0]    INTEVENT                            = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?),0x08 (?),0x09 (?),0x0A (?),0x0B (?),0x0C (?),0x0D (?),0x0E (?),0x0F (?),0x10 (?),0x11 (?),0x12 (?),0x13 (?),0x14 (?),0x15 (?),0x16 (?),0x17 (?),0x18 (?),0x19 (?),0x1A (?),0x1B (?),0x1C (?),0x1D (?),0x1E (?),0x1F (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00584600$ PER_TESLA9X45_Part5.per -queue SNOC_TPRB1_SPROF_COUNTERS_10_SRC"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00584604
tree " SNOC_TPRB1_SPROF_COUNTERS_10_ALARMMODE [RW]                       0x00584604"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x00000003    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_TPRB1_SPROF_COUNTERS_10_ALARMMODE PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   0.--1.       "[1 : 0]    COUNTERS_10_ALARMMODE               = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00584604$ PER_TESLA9X45_Part5.per -queue SNOC_TPRB1_SPROF_COUNTERS_10_ALARMMODE"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00584608
tree " SNOC_TPRB1_SPROF_COUNTERS_10_VAL [R]                              0x00584608"
  group.long 0x0--0x3
   textline "POR 0xDEADBEEF [0xxxxxxxxx]    MASK =  "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_TPRB1_SPROF_COUNTERS_10_VAL PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.word 0 0.--15. 1  "[15 : 0]   COUNTERS_10_VAL                     = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00584608$ PER_TESLA9X45_Part5.per -queue SNOC_TPRB1_SPROF_COUNTERS_10_VAL"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00584614
tree " SNOC_TPRB1_SPROF_COUNTERS_11_SRC [RW]                             0x00584614"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x0000003F    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_TPRB1_SPROF_COUNTERS_11_SRC PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   5.           "[ 5 ]      EXTEVENT                            = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   0.--4.       "[4 : 0]    INTEVENT                            = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?),0x08 (?),0x09 (?),0x0A (?),0x0B (?),0x0C (?),0x0D (?),0x0E (?),0x0F (?),0x10 (?),0x11 (?),0x12 (?),0x13 (?),0x14 (?),0x15 (?),0x16 (?),0x17 (?),0x18 (?),0x19 (?),0x1A (?),0x1B (?),0x1C (?),0x1D (?),0x1E (?),0x1F (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00584614$ PER_TESLA9X45_Part5.per -queue SNOC_TPRB1_SPROF_COUNTERS_11_SRC"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00584618
tree " SNOC_TPRB1_SPROF_COUNTERS_11_ALARMMODE [RW]                       0x00584618"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x00000003    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_TPRB1_SPROF_COUNTERS_11_ALARMMODE PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   0.--1.       "[1 : 0]    COUNTERS_11_ALARMMODE               = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00584618$ PER_TESLA9X45_Part5.per -queue SNOC_TPRB1_SPROF_COUNTERS_11_ALARMMODE"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0058461C
tree " SNOC_TPRB1_SPROF_COUNTERS_11_VAL [R]                              0x0058461C"
  group.long 0x0--0x3
   textline "POR 0xDEADBEEF [0xxxxxxxxx]    MASK =  "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_TPRB1_SPROF_COUNTERS_11_VAL PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.word 0 0.--15. 1  "[15 : 0]   COUNTERS_11_VAL                     = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0058461C$ PER_TESLA9X45_Part5.per -queue SNOC_TPRB1_SPROF_COUNTERS_11_VAL"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00584628
tree " SNOC_TPRB1_SPROF_COUNTERS_12_SRC [RW]                             0x00584628"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x0000003F    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_TPRB1_SPROF_COUNTERS_12_SRC PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   5.           "[ 5 ]      EXTEVENT                            = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   0.--4.       "[4 : 0]    INTEVENT                            = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?),0x08 (?),0x09 (?),0x0A (?),0x0B (?),0x0C (?),0x0D (?),0x0E (?),0x0F (?),0x10 (?),0x11 (?),0x12 (?),0x13 (?),0x14 (?),0x15 (?),0x16 (?),0x17 (?),0x18 (?),0x19 (?),0x1A (?),0x1B (?),0x1C (?),0x1D (?),0x1E (?),0x1F (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00584628$ PER_TESLA9X45_Part5.per -queue SNOC_TPRB1_SPROF_COUNTERS_12_SRC"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0058462C
tree " SNOC_TPRB1_SPROF_COUNTERS_12_ALARMMODE [RW]                       0x0058462C"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x00000003    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_TPRB1_SPROF_COUNTERS_12_ALARMMODE PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   0.--1.       "[1 : 0]    COUNTERS_12_ALARMMODE               = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0058462C$ PER_TESLA9X45_Part5.per -queue SNOC_TPRB1_SPROF_COUNTERS_12_ALARMMODE"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00584630
tree " SNOC_TPRB1_SPROF_COUNTERS_12_VAL [R]                              0x00584630"
  group.long 0x0--0x3
   textline "POR 0xDEADBEEF [0xxxxxxxxx]    MASK =  "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_TPRB1_SPROF_COUNTERS_12_VAL PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.word 0 0.--15. 1  "[15 : 0]   COUNTERS_12_VAL                     = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00584630$ PER_TESLA9X45_Part5.per -queue SNOC_TPRB1_SPROF_COUNTERS_12_VAL"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0058463C
tree " SNOC_TPRB1_SPROF_COUNTERS_13_SRC [RW]                             0x0058463C"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x0000003F    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_TPRB1_SPROF_COUNTERS_13_SRC PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   5.           "[ 5 ]      EXTEVENT                            = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   0.--4.       "[4 : 0]    INTEVENT                            = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?),0x08 (?),0x09 (?),0x0A (?),0x0B (?),0x0C (?),0x0D (?),0x0E (?),0x0F (?),0x10 (?),0x11 (?),0x12 (?),0x13 (?),0x14 (?),0x15 (?),0x16 (?),0x17 (?),0x18 (?),0x19 (?),0x1A (?),0x1B (?),0x1C (?),0x1D (?),0x1E (?),0x1F (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0058463C$ PER_TESLA9X45_Part5.per -queue SNOC_TPRB1_SPROF_COUNTERS_13_SRC"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00584640
tree " SNOC_TPRB1_SPROF_COUNTERS_13_ALARMMODE [RW]                       0x00584640"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x00000003    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_TPRB1_SPROF_COUNTERS_13_ALARMMODE PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   0.--1.       "[1 : 0]    COUNTERS_13_ALARMMODE               = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00584640$ PER_TESLA9X45_Part5.per -queue SNOC_TPRB1_SPROF_COUNTERS_13_ALARMMODE"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00584644
tree " SNOC_TPRB1_SPROF_COUNTERS_13_VAL [R]                              0x00584644"
  group.long 0x0--0x3
   textline "POR 0xDEADBEEF [0xxxxxxxxx]    MASK =  "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_TPRB1_SPROF_COUNTERS_13_VAL PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.word 0 0.--15. 1  "[15 : 0]   COUNTERS_13_VAL                     = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00584644$ PER_TESLA9X45_Part5.per -queue SNOC_TPRB1_SPROF_COUNTERS_13_VAL"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00584650
tree " SNOC_TPRB1_SPROF_COUNTERS_14_SRC [RW]                             0x00584650"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x0000003F    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_TPRB1_SPROF_COUNTERS_14_SRC PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   5.           "[ 5 ]      EXTEVENT                            = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   0.--4.       "[4 : 0]    INTEVENT                            = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?),0x08 (?),0x09 (?),0x0A (?),0x0B (?),0x0C (?),0x0D (?),0x0E (?),0x0F (?),0x10 (?),0x11 (?),0x12 (?),0x13 (?),0x14 (?),0x15 (?),0x16 (?),0x17 (?),0x18 (?),0x19 (?),0x1A (?),0x1B (?),0x1C (?),0x1D (?),0x1E (?),0x1F (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00584650$ PER_TESLA9X45_Part5.per -queue SNOC_TPRB1_SPROF_COUNTERS_14_SRC"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00584654
tree " SNOC_TPRB1_SPROF_COUNTERS_14_ALARMMODE [RW]                       0x00584654"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x00000003    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_TPRB1_SPROF_COUNTERS_14_ALARMMODE PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   0.--1.       "[1 : 0]    COUNTERS_14_ALARMMODE               = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00584654$ PER_TESLA9X45_Part5.per -queue SNOC_TPRB1_SPROF_COUNTERS_14_ALARMMODE"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00584658
tree " SNOC_TPRB1_SPROF_COUNTERS_14_VAL [R]                              0x00584658"
  group.long 0x0--0x3
   textline "POR 0xDEADBEEF [0xxxxxxxxx]    MASK =  "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_TPRB1_SPROF_COUNTERS_14_VAL PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.word 0 0.--15. 1  "[15 : 0]   COUNTERS_14_VAL                     = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00584658$ PER_TESLA9X45_Part5.per -queue SNOC_TPRB1_SPROF_COUNTERS_14_VAL"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00584664
tree " SNOC_TPRB1_SPROF_COUNTERS_15_SRC [RW]                             0x00584664"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x0000003F    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_TPRB1_SPROF_COUNTERS_15_SRC PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   5.           "[ 5 ]      EXTEVENT                            = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   0.--4.       "[4 : 0]    INTEVENT                            = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?),0x08 (?),0x09 (?),0x0A (?),0x0B (?),0x0C (?),0x0D (?),0x0E (?),0x0F (?),0x10 (?),0x11 (?),0x12 (?),0x13 (?),0x14 (?),0x15 (?),0x16 (?),0x17 (?),0x18 (?),0x19 (?),0x1A (?),0x1B (?),0x1C (?),0x1D (?),0x1E (?),0x1F (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00584664$ PER_TESLA9X45_Part5.per -queue SNOC_TPRB1_SPROF_COUNTERS_15_SRC"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00584668
tree " SNOC_TPRB1_SPROF_COUNTERS_15_ALARMMODE [RW]                       0x00584668"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x00000003    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_TPRB1_SPROF_COUNTERS_15_ALARMMODE PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   0.--1.       "[1 : 0]    COUNTERS_15_ALARMMODE               = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00584668$ PER_TESLA9X45_Part5.per -queue SNOC_TPRB1_SPROF_COUNTERS_15_ALARMMODE"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0058466C
tree " SNOC_TPRB1_SPROF_COUNTERS_15_VAL [R]                              0x0058466C"
  group.long 0x0--0x3
   textline "POR 0xDEADBEEF [0xxxxxxxxx]    MASK =  "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_TPRB1_SPROF_COUNTERS_15_VAL PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.word 0 0.--15. 1  "[15 : 0]   COUNTERS_15_VAL                     = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0058466C$ PER_TESLA9X45_Part5.per -queue SNOC_TPRB1_SPROF_COUNTERS_15_VAL"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00584800
tree " SNOC_TPRB2_SPROF_ID_COREID [R]                                    0x00584800"
  group.long 0x0--0x3
   textline "POR 0x273E7806    MASK = 0xFFFFFFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_TPRB2_SPROF_ID_COREID PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.long 0 8.--31. 1  "[31 : 8]   CORECHECKSUM                        = "
   textline ""
   hexmask.long.byte 0 0.--7. 1   "[7 : 0]    CORETYPEID                          = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00584800$ PER_TESLA9X45_Part5.per -queue SNOC_TPRB2_SPROF_ID_COREID"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00584804
tree " SNOC_TPRB2_SPROF_ID_REVISIONID [R]                                0x00584804"
  group.long 0x0--0x3
   textline "POR 0x00049C00    MASK = 0xFFFFFFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_TPRB2_SPROF_ID_REVISIONID PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.long 0 8.--31. 1  "[31 : 8]   FLEXNOCID                           = "
   textline ""
   hexmask.long.byte 0 0.--7. 1   "[7 : 0]    USERID                              = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00584804$ PER_TESLA9X45_Part5.per -queue SNOC_TPRB2_SPROF_ID_REVISIONID"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00584808
tree " SNOC_TPRB2_SPROF_MAINCTL [RW]                                     0x00584808"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x000000FF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_TPRB2_SPROF_MAINCTL PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   7.           "[ 7 ]      FILTBYTEALWAYSCHAINABLEEN           = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   6.           "[ 6 ]      INTRUSIVEMODE                       = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   5.           "[ 5 ]      STATCONDDUMP                        = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   4.           "[ 4 ]      ALARMEN                             = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   3.           "[ 3 ]      STATEN                              = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   2.           "[ 2 ]      PAYLOADEN                           = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   1.           "[ 1 ]      TRACEEN                             = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   0.           "[ 0 ]      ERREN                               = " "0x00 (?),0x01 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00584808$ PER_TESLA9X45_Part5.per -queue SNOC_TPRB2_SPROF_MAINCTL"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0058480C
tree " SNOC_TPRB2_SPROF_CFGCTL [RW]                                      0x0058480C"
  group.long 0x0--0x3
   textline "POR 0xDEADBEEF [0xxxxxxxxx]    MASK =  "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_TPRB2_SPROF_CFGCTL PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   1.           "[ 1 ]      ACTIVE                              = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   0.           "[ 0 ]      GLOBALEN                            = " "0x00 (?),0x01 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0058480C$ PER_TESLA9X45_Part5.per -queue SNOC_TPRB2_SPROF_CFGCTL"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00584824
tree " SNOC_TPRB2_SPROF_STATPERIOD [RW]                                  0x00584824"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x0000001F    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_TPRB2_SPROF_STATPERIOD PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   0.--4.       "[4 : 0]    STATPERIOD                          = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?),0x08 (?),0x09 (?),0x0A (?),0x0B (?),0x0C (?),0x0D (?),0x0E (?),0x0F (?),0x10 (?),0x11 (?),0x12 (?),0x13 (?),0x14 (?),0x15 (?),0x16 (?),0x17 (?),0x18 (?),0x19 (?),0x1A (?),0x1B (?),0x1C (?),0x1D (?),0x1E (?),0x1F (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00584824$ PER_TESLA9X45_Part5.per -queue SNOC_TPRB2_SPROF_STATPERIOD"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00584828
tree " SNOC_TPRB2_SPROF_STATGO [RW]                                      0x00584828"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x00000001    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_TPRB2_SPROF_STATGO PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   0.           "[ 0 ]      STATGO                              = " "0x00 (?),0x01 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00584828$ PER_TESLA9X45_Part5.per -queue SNOC_TPRB2_SPROF_STATGO"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0058482C
tree " SNOC_TPRB2_SPROF_STATALARMMIN [RW]                                0x0058482C"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0xFFFFFFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_TPRB2_SPROF_STATALARMMIN PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.long 0 0.--31. 1  "[31 : 0]   STATALARMMIN                        = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0058482C$ PER_TESLA9X45_Part5.per -queue SNOC_TPRB2_SPROF_STATALARMMIN"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00584830
tree " SNOC_TPRB2_SPROF_STATALARMMAX [RW]                                0x00584830"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0xFFFFFFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_TPRB2_SPROF_STATALARMMAX PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.long 0 0.--31. 1  "[31 : 0]   STATALARMMAX                        = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00584830$ PER_TESLA9X45_Part5.per -queue SNOC_TPRB2_SPROF_STATALARMMAX"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00584834
tree " SNOC_TPRB2_SPROF_STATALARMSTATUS [R]                              0x00584834"
  group.long 0x0--0x3
   textline "POR 0xDEADBEEF [0xxxxxxxxx]    MASK =  "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_TPRB2_SPROF_STATALARMSTATUS PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   0.           "[ 0 ]      STATALARMSTATUS                     = " "0x00 (?),0x01 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00584834$ PER_TESLA9X45_Part5.per -queue SNOC_TPRB2_SPROF_STATALARMSTATUS"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00584838
tree " SNOC_TPRB2_SPROF_STATALARMCLR [RW]                                0x00584838"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x00000001    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_TPRB2_SPROF_STATALARMCLR PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   0.           "[ 0 ]      STATALARMCLR                        = " "0x00 (?),0x01 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00584838$ PER_TESLA9X45_Part5.per -queue SNOC_TPRB2_SPROF_STATALARMCLR"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00584938
tree " SNOC_TPRB2_SPROF_COUNTERS_0_SRC [RW]                              0x00584938"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x0000003F    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_TPRB2_SPROF_COUNTERS_0_SRC PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   5.           "[ 5 ]      EXTEVENT                            = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   0.--4.       "[4 : 0]    INTEVENT                            = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?),0x08 (?),0x09 (?),0x0A (?),0x0B (?),0x0C (?),0x0D (?),0x0E (?),0x0F (?),0x10 (?),0x11 (?),0x12 (?),0x13 (?),0x14 (?),0x15 (?),0x16 (?),0x17 (?),0x18 (?),0x19 (?),0x1A (?),0x1B (?),0x1C (?),0x1D (?),0x1E (?),0x1F (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00584938$ PER_TESLA9X45_Part5.per -queue SNOC_TPRB2_SPROF_COUNTERS_0_SRC"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0058493C
tree " SNOC_TPRB2_SPROF_COUNTERS_0_ALARMMODE [RW]                        0x0058493C"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x00000003    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_TPRB2_SPROF_COUNTERS_0_ALARMMODE PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   0.--1.       "[1 : 0]    COUNTERS_0_ALARMMODE                = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0058493C$ PER_TESLA9X45_Part5.per -queue SNOC_TPRB2_SPROF_COUNTERS_0_ALARMMODE"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00584940
tree " SNOC_TPRB2_SPROF_COUNTERS_0_VAL [R]                               0x00584940"
  group.long 0x0--0x3
   textline "POR 0xDEADBEEF [0xxxxxxxxx]    MASK =  "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_TPRB2_SPROF_COUNTERS_0_VAL PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.word 0 0.--15. 1  "[15 : 0]   COUNTERS_0_VAL                      = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00584940$ PER_TESLA9X45_Part5.per -queue SNOC_TPRB2_SPROF_COUNTERS_0_VAL"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0058494C
tree " SNOC_TPRB2_SPROF_COUNTERS_1_SRC [RW]                              0x0058494C"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x0000003F    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_TPRB2_SPROF_COUNTERS_1_SRC PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   5.           "[ 5 ]      EXTEVENT                            = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   0.--4.       "[4 : 0]    INTEVENT                            = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?),0x08 (?),0x09 (?),0x0A (?),0x0B (?),0x0C (?),0x0D (?),0x0E (?),0x0F (?),0x10 (?),0x11 (?),0x12 (?),0x13 (?),0x14 (?),0x15 (?),0x16 (?),0x17 (?),0x18 (?),0x19 (?),0x1A (?),0x1B (?),0x1C (?),0x1D (?),0x1E (?),0x1F (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0058494C$ PER_TESLA9X45_Part5.per -queue SNOC_TPRB2_SPROF_COUNTERS_1_SRC"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00584950
tree " SNOC_TPRB2_SPROF_COUNTERS_1_ALARMMODE [RW]                        0x00584950"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x00000003    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_TPRB2_SPROF_COUNTERS_1_ALARMMODE PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   0.--1.       "[1 : 0]    COUNTERS_1_ALARMMODE                = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00584950$ PER_TESLA9X45_Part5.per -queue SNOC_TPRB2_SPROF_COUNTERS_1_ALARMMODE"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00584954
tree " SNOC_TPRB2_SPROF_COUNTERS_1_VAL [R]                               0x00584954"
  group.long 0x0--0x3
   textline "POR 0xDEADBEEF [0xxxxxxxxx]    MASK =  "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_TPRB2_SPROF_COUNTERS_1_VAL PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.word 0 0.--15. 1  "[15 : 0]   COUNTERS_1_VAL                      = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00584954$ PER_TESLA9X45_Part5.per -queue SNOC_TPRB2_SPROF_COUNTERS_1_VAL"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00584960
tree " SNOC_TPRB2_SPROF_COUNTERS_2_SRC [RW]                              0x00584960"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x0000003F    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_TPRB2_SPROF_COUNTERS_2_SRC PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   5.           "[ 5 ]      EXTEVENT                            = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   0.--4.       "[4 : 0]    INTEVENT                            = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?),0x08 (?),0x09 (?),0x0A (?),0x0B (?),0x0C (?),0x0D (?),0x0E (?),0x0F (?),0x10 (?),0x11 (?),0x12 (?),0x13 (?),0x14 (?),0x15 (?),0x16 (?),0x17 (?),0x18 (?),0x19 (?),0x1A (?),0x1B (?),0x1C (?),0x1D (?),0x1E (?),0x1F (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00584960$ PER_TESLA9X45_Part5.per -queue SNOC_TPRB2_SPROF_COUNTERS_2_SRC"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00584964
tree " SNOC_TPRB2_SPROF_COUNTERS_2_ALARMMODE [RW]                        0x00584964"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x00000003    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_TPRB2_SPROF_COUNTERS_2_ALARMMODE PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   0.--1.       "[1 : 0]    COUNTERS_2_ALARMMODE                = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00584964$ PER_TESLA9X45_Part5.per -queue SNOC_TPRB2_SPROF_COUNTERS_2_ALARMMODE"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00584968
tree " SNOC_TPRB2_SPROF_COUNTERS_2_VAL [R]                               0x00584968"
  group.long 0x0--0x3
   textline "POR 0xDEADBEEF [0xxxxxxxxx]    MASK =  "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_TPRB2_SPROF_COUNTERS_2_VAL PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.word 0 0.--15. 1  "[15 : 0]   COUNTERS_2_VAL                      = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00584968$ PER_TESLA9X45_Part5.per -queue SNOC_TPRB2_SPROF_COUNTERS_2_VAL"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00584974
tree " SNOC_TPRB2_SPROF_COUNTERS_3_SRC [RW]                              0x00584974"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x0000003F    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_TPRB2_SPROF_COUNTERS_3_SRC PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   5.           "[ 5 ]      EXTEVENT                            = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   0.--4.       "[4 : 0]    INTEVENT                            = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?),0x08 (?),0x09 (?),0x0A (?),0x0B (?),0x0C (?),0x0D (?),0x0E (?),0x0F (?),0x10 (?),0x11 (?),0x12 (?),0x13 (?),0x14 (?),0x15 (?),0x16 (?),0x17 (?),0x18 (?),0x19 (?),0x1A (?),0x1B (?),0x1C (?),0x1D (?),0x1E (?),0x1F (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00584974$ PER_TESLA9X45_Part5.per -queue SNOC_TPRB2_SPROF_COUNTERS_3_SRC"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00584978
tree " SNOC_TPRB2_SPROF_COUNTERS_3_ALARMMODE [RW]                        0x00584978"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x00000003    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_TPRB2_SPROF_COUNTERS_3_ALARMMODE PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   0.--1.       "[1 : 0]    COUNTERS_3_ALARMMODE                = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00584978$ PER_TESLA9X45_Part5.per -queue SNOC_TPRB2_SPROF_COUNTERS_3_ALARMMODE"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0058497C
tree " SNOC_TPRB2_SPROF_COUNTERS_3_VAL [R]                               0x0058497C"
  group.long 0x0--0x3
   textline "POR 0xDEADBEEF [0xxxxxxxxx]    MASK =  "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_TPRB2_SPROF_COUNTERS_3_VAL PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.word 0 0.--15. 1  "[15 : 0]   COUNTERS_3_VAL                      = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0058497C$ PER_TESLA9X45_Part5.per -queue SNOC_TPRB2_SPROF_COUNTERS_3_VAL"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00584988
tree " SNOC_TPRB2_SPROF_COUNTERS_4_SRC [RW]                              0x00584988"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x0000003F    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_TPRB2_SPROF_COUNTERS_4_SRC PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   5.           "[ 5 ]      EXTEVENT                            = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   0.--4.       "[4 : 0]    INTEVENT                            = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?),0x08 (?),0x09 (?),0x0A (?),0x0B (?),0x0C (?),0x0D (?),0x0E (?),0x0F (?),0x10 (?),0x11 (?),0x12 (?),0x13 (?),0x14 (?),0x15 (?),0x16 (?),0x17 (?),0x18 (?),0x19 (?),0x1A (?),0x1B (?),0x1C (?),0x1D (?),0x1E (?),0x1F (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00584988$ PER_TESLA9X45_Part5.per -queue SNOC_TPRB2_SPROF_COUNTERS_4_SRC"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0058498C
tree " SNOC_TPRB2_SPROF_COUNTERS_4_ALARMMODE [RW]                        0x0058498C"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x00000003    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_TPRB2_SPROF_COUNTERS_4_ALARMMODE PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   0.--1.       "[1 : 0]    COUNTERS_4_ALARMMODE                = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0058498C$ PER_TESLA9X45_Part5.per -queue SNOC_TPRB2_SPROF_COUNTERS_4_ALARMMODE"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00584990
tree " SNOC_TPRB2_SPROF_COUNTERS_4_VAL [R]                               0x00584990"
  group.long 0x0--0x3
   textline "POR 0xDEADBEEF [0xxxxxxxxx]    MASK =  "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_TPRB2_SPROF_COUNTERS_4_VAL PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.word 0 0.--15. 1  "[15 : 0]   COUNTERS_4_VAL                      = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00584990$ PER_TESLA9X45_Part5.per -queue SNOC_TPRB2_SPROF_COUNTERS_4_VAL"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0058499C
tree " SNOC_TPRB2_SPROF_COUNTERS_5_SRC [RW]                              0x0058499C"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x0000003F    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_TPRB2_SPROF_COUNTERS_5_SRC PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   5.           "[ 5 ]      EXTEVENT                            = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   0.--4.       "[4 : 0]    INTEVENT                            = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?),0x08 (?),0x09 (?),0x0A (?),0x0B (?),0x0C (?),0x0D (?),0x0E (?),0x0F (?),0x10 (?),0x11 (?),0x12 (?),0x13 (?),0x14 (?),0x15 (?),0x16 (?),0x17 (?),0x18 (?),0x19 (?),0x1A (?),0x1B (?),0x1C (?),0x1D (?),0x1E (?),0x1F (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0058499C$ PER_TESLA9X45_Part5.per -queue SNOC_TPRB2_SPROF_COUNTERS_5_SRC"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x005849A0
tree " SNOC_TPRB2_SPROF_COUNTERS_5_ALARMMODE [RW]                        0x005849A0"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x00000003    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_TPRB2_SPROF_COUNTERS_5_ALARMMODE PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   0.--1.       "[1 : 0]    COUNTERS_5_ALARMMODE                = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x005849A0$ PER_TESLA9X45_Part5.per -queue SNOC_TPRB2_SPROF_COUNTERS_5_ALARMMODE"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x005849A4
tree " SNOC_TPRB2_SPROF_COUNTERS_5_VAL [R]                               0x005849A4"
  group.long 0x0--0x3
   textline "POR 0xDEADBEEF [0xxxxxxxxx]    MASK =  "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_TPRB2_SPROF_COUNTERS_5_VAL PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.word 0 0.--15. 1  "[15 : 0]   COUNTERS_5_VAL                      = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x005849A4$ PER_TESLA9X45_Part5.per -queue SNOC_TPRB2_SPROF_COUNTERS_5_VAL"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x005849B0
tree " SNOC_TPRB2_SPROF_COUNTERS_6_SRC [RW]                              0x005849B0"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x0000003F    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_TPRB2_SPROF_COUNTERS_6_SRC PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   5.           "[ 5 ]      EXTEVENT                            = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   0.--4.       "[4 : 0]    INTEVENT                            = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?),0x08 (?),0x09 (?),0x0A (?),0x0B (?),0x0C (?),0x0D (?),0x0E (?),0x0F (?),0x10 (?),0x11 (?),0x12 (?),0x13 (?),0x14 (?),0x15 (?),0x16 (?),0x17 (?),0x18 (?),0x19 (?),0x1A (?),0x1B (?),0x1C (?),0x1D (?),0x1E (?),0x1F (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x005849B0$ PER_TESLA9X45_Part5.per -queue SNOC_TPRB2_SPROF_COUNTERS_6_SRC"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x005849B4
tree " SNOC_TPRB2_SPROF_COUNTERS_6_ALARMMODE [RW]                        0x005849B4"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x00000003    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_TPRB2_SPROF_COUNTERS_6_ALARMMODE PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   0.--1.       "[1 : 0]    COUNTERS_6_ALARMMODE                = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x005849B4$ PER_TESLA9X45_Part5.per -queue SNOC_TPRB2_SPROF_COUNTERS_6_ALARMMODE"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x005849B8
tree " SNOC_TPRB2_SPROF_COUNTERS_6_VAL [R]                               0x005849B8"
  group.long 0x0--0x3
   textline "POR 0xDEADBEEF [0xxxxxxxxx]    MASK =  "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_TPRB2_SPROF_COUNTERS_6_VAL PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.word 0 0.--15. 1  "[15 : 0]   COUNTERS_6_VAL                      = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x005849B8$ PER_TESLA9X45_Part5.per -queue SNOC_TPRB2_SPROF_COUNTERS_6_VAL"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x005849C4
tree " SNOC_TPRB2_SPROF_COUNTERS_7_SRC [RW]                              0x005849C4"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x0000003F    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_TPRB2_SPROF_COUNTERS_7_SRC PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   5.           "[ 5 ]      EXTEVENT                            = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   0.--4.       "[4 : 0]    INTEVENT                            = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?),0x08 (?),0x09 (?),0x0A (?),0x0B (?),0x0C (?),0x0D (?),0x0E (?),0x0F (?),0x10 (?),0x11 (?),0x12 (?),0x13 (?),0x14 (?),0x15 (?),0x16 (?),0x17 (?),0x18 (?),0x19 (?),0x1A (?),0x1B (?),0x1C (?),0x1D (?),0x1E (?),0x1F (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x005849C4$ PER_TESLA9X45_Part5.per -queue SNOC_TPRB2_SPROF_COUNTERS_7_SRC"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x005849C8
tree " SNOC_TPRB2_SPROF_COUNTERS_7_ALARMMODE [RW]                        0x005849C8"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x00000003    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_TPRB2_SPROF_COUNTERS_7_ALARMMODE PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   0.--1.       "[1 : 0]    COUNTERS_7_ALARMMODE                = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x005849C8$ PER_TESLA9X45_Part5.per -queue SNOC_TPRB2_SPROF_COUNTERS_7_ALARMMODE"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x005849CC
tree " SNOC_TPRB2_SPROF_COUNTERS_7_VAL [R]                               0x005849CC"
  group.long 0x0--0x3
   textline "POR 0xDEADBEEF [0xxxxxxxxx]    MASK =  "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_TPRB2_SPROF_COUNTERS_7_VAL PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.word 0 0.--15. 1  "[15 : 0]   COUNTERS_7_VAL                      = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x005849CC$ PER_TESLA9X45_Part5.per -queue SNOC_TPRB2_SPROF_COUNTERS_7_VAL"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x005849D8
tree " SNOC_TPRB2_SPROF_COUNTERS_8_SRC [RW]                              0x005849D8"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x0000003F    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_TPRB2_SPROF_COUNTERS_8_SRC PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   5.           "[ 5 ]      EXTEVENT                            = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   0.--4.       "[4 : 0]    INTEVENT                            = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?),0x08 (?),0x09 (?),0x0A (?),0x0B (?),0x0C (?),0x0D (?),0x0E (?),0x0F (?),0x10 (?),0x11 (?),0x12 (?),0x13 (?),0x14 (?),0x15 (?),0x16 (?),0x17 (?),0x18 (?),0x19 (?),0x1A (?),0x1B (?),0x1C (?),0x1D (?),0x1E (?),0x1F (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x005849D8$ PER_TESLA9X45_Part5.per -queue SNOC_TPRB2_SPROF_COUNTERS_8_SRC"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x005849DC
tree " SNOC_TPRB2_SPROF_COUNTERS_8_ALARMMODE [RW]                        0x005849DC"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x00000003    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_TPRB2_SPROF_COUNTERS_8_ALARMMODE PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   0.--1.       "[1 : 0]    COUNTERS_8_ALARMMODE                = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x005849DC$ PER_TESLA9X45_Part5.per -queue SNOC_TPRB2_SPROF_COUNTERS_8_ALARMMODE"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x005849E0
tree " SNOC_TPRB2_SPROF_COUNTERS_8_VAL [R]                               0x005849E0"
  group.long 0x0--0x3
   textline "POR 0xDEADBEEF [0xxxxxxxxx]    MASK =  "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_TPRB2_SPROF_COUNTERS_8_VAL PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.word 0 0.--15. 1  "[15 : 0]   COUNTERS_8_VAL                      = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x005849E0$ PER_TESLA9X45_Part5.per -queue SNOC_TPRB2_SPROF_COUNTERS_8_VAL"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x005849EC
tree " SNOC_TPRB2_SPROF_COUNTERS_9_SRC [RW]                              0x005849EC"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x0000003F    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_TPRB2_SPROF_COUNTERS_9_SRC PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   5.           "[ 5 ]      EXTEVENT                            = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   0.--4.       "[4 : 0]    INTEVENT                            = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?),0x08 (?),0x09 (?),0x0A (?),0x0B (?),0x0C (?),0x0D (?),0x0E (?),0x0F (?),0x10 (?),0x11 (?),0x12 (?),0x13 (?),0x14 (?),0x15 (?),0x16 (?),0x17 (?),0x18 (?),0x19 (?),0x1A (?),0x1B (?),0x1C (?),0x1D (?),0x1E (?),0x1F (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x005849EC$ PER_TESLA9X45_Part5.per -queue SNOC_TPRB2_SPROF_COUNTERS_9_SRC"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x005849F0
tree " SNOC_TPRB2_SPROF_COUNTERS_9_ALARMMODE [RW]                        0x005849F0"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x00000003    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_TPRB2_SPROF_COUNTERS_9_ALARMMODE PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   0.--1.       "[1 : 0]    COUNTERS_9_ALARMMODE                = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x005849F0$ PER_TESLA9X45_Part5.per -queue SNOC_TPRB2_SPROF_COUNTERS_9_ALARMMODE"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x005849F4
tree " SNOC_TPRB2_SPROF_COUNTERS_9_VAL [R]                               0x005849F4"
  group.long 0x0--0x3
   textline "POR 0xDEADBEEF [0xxxxxxxxx]    MASK =  "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_TPRB2_SPROF_COUNTERS_9_VAL PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.word 0 0.--15. 1  "[15 : 0]   COUNTERS_9_VAL                      = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x005849F4$ PER_TESLA9X45_Part5.per -queue SNOC_TPRB2_SPROF_COUNTERS_9_VAL"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00584A00
tree " SNOC_TPRB2_SPROF_COUNTERS_10_SRC [RW]                             0x00584A00"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x0000003F    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_TPRB2_SPROF_COUNTERS_10_SRC PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   5.           "[ 5 ]      EXTEVENT                            = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   0.--4.       "[4 : 0]    INTEVENT                            = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?),0x08 (?),0x09 (?),0x0A (?),0x0B (?),0x0C (?),0x0D (?),0x0E (?),0x0F (?),0x10 (?),0x11 (?),0x12 (?),0x13 (?),0x14 (?),0x15 (?),0x16 (?),0x17 (?),0x18 (?),0x19 (?),0x1A (?),0x1B (?),0x1C (?),0x1D (?),0x1E (?),0x1F (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00584A00$ PER_TESLA9X45_Part5.per -queue SNOC_TPRB2_SPROF_COUNTERS_10_SRC"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00584A04
tree " SNOC_TPRB2_SPROF_COUNTERS_10_ALARMMODE [RW]                       0x00584A04"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x00000003    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_TPRB2_SPROF_COUNTERS_10_ALARMMODE PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   0.--1.       "[1 : 0]    COUNTERS_10_ALARMMODE               = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00584A04$ PER_TESLA9X45_Part5.per -queue SNOC_TPRB2_SPROF_COUNTERS_10_ALARMMODE"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00584A08
tree " SNOC_TPRB2_SPROF_COUNTERS_10_VAL [R]                              0x00584A08"
  group.long 0x0--0x3
   textline "POR 0xDEADBEEF [0xxxxxxxxx]    MASK =  "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_TPRB2_SPROF_COUNTERS_10_VAL PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.word 0 0.--15. 1  "[15 : 0]   COUNTERS_10_VAL                     = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00584A08$ PER_TESLA9X45_Part5.per -queue SNOC_TPRB2_SPROF_COUNTERS_10_VAL"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00584A14
tree " SNOC_TPRB2_SPROF_COUNTERS_11_SRC [RW]                             0x00584A14"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x0000003F    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_TPRB2_SPROF_COUNTERS_11_SRC PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   5.           "[ 5 ]      EXTEVENT                            = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   0.--4.       "[4 : 0]    INTEVENT                            = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?),0x08 (?),0x09 (?),0x0A (?),0x0B (?),0x0C (?),0x0D (?),0x0E (?),0x0F (?),0x10 (?),0x11 (?),0x12 (?),0x13 (?),0x14 (?),0x15 (?),0x16 (?),0x17 (?),0x18 (?),0x19 (?),0x1A (?),0x1B (?),0x1C (?),0x1D (?),0x1E (?),0x1F (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00584A14$ PER_TESLA9X45_Part5.per -queue SNOC_TPRB2_SPROF_COUNTERS_11_SRC"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00584A18
tree " SNOC_TPRB2_SPROF_COUNTERS_11_ALARMMODE [RW]                       0x00584A18"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x00000003    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_TPRB2_SPROF_COUNTERS_11_ALARMMODE PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   0.--1.       "[1 : 0]    COUNTERS_11_ALARMMODE               = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00584A18$ PER_TESLA9X45_Part5.per -queue SNOC_TPRB2_SPROF_COUNTERS_11_ALARMMODE"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00584A1C
tree " SNOC_TPRB2_SPROF_COUNTERS_11_VAL [R]                              0x00584A1C"
  group.long 0x0--0x3
   textline "POR 0xDEADBEEF [0xxxxxxxxx]    MASK =  "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_TPRB2_SPROF_COUNTERS_11_VAL PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.word 0 0.--15. 1  "[15 : 0]   COUNTERS_11_VAL                     = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00584A1C$ PER_TESLA9X45_Part5.per -queue SNOC_TPRB2_SPROF_COUNTERS_11_VAL"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00584A28
tree " SNOC_TPRB2_SPROF_COUNTERS_12_SRC [RW]                             0x00584A28"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x0000003F    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_TPRB2_SPROF_COUNTERS_12_SRC PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   5.           "[ 5 ]      EXTEVENT                            = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   0.--4.       "[4 : 0]    INTEVENT                            = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?),0x08 (?),0x09 (?),0x0A (?),0x0B (?),0x0C (?),0x0D (?),0x0E (?),0x0F (?),0x10 (?),0x11 (?),0x12 (?),0x13 (?),0x14 (?),0x15 (?),0x16 (?),0x17 (?),0x18 (?),0x19 (?),0x1A (?),0x1B (?),0x1C (?),0x1D (?),0x1E (?),0x1F (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00584A28$ PER_TESLA9X45_Part5.per -queue SNOC_TPRB2_SPROF_COUNTERS_12_SRC"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00584A2C
tree " SNOC_TPRB2_SPROF_COUNTERS_12_ALARMMODE [RW]                       0x00584A2C"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x00000003    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_TPRB2_SPROF_COUNTERS_12_ALARMMODE PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   0.--1.       "[1 : 0]    COUNTERS_12_ALARMMODE               = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00584A2C$ PER_TESLA9X45_Part5.per -queue SNOC_TPRB2_SPROF_COUNTERS_12_ALARMMODE"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00584A30
tree " SNOC_TPRB2_SPROF_COUNTERS_12_VAL [R]                              0x00584A30"
  group.long 0x0--0x3
   textline "POR 0xDEADBEEF [0xxxxxxxxx]    MASK =  "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_TPRB2_SPROF_COUNTERS_12_VAL PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.word 0 0.--15. 1  "[15 : 0]   COUNTERS_12_VAL                     = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00584A30$ PER_TESLA9X45_Part5.per -queue SNOC_TPRB2_SPROF_COUNTERS_12_VAL"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00584A3C
tree " SNOC_TPRB2_SPROF_COUNTERS_13_SRC [RW]                             0x00584A3C"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x0000003F    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_TPRB2_SPROF_COUNTERS_13_SRC PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   5.           "[ 5 ]      EXTEVENT                            = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   0.--4.       "[4 : 0]    INTEVENT                            = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?),0x08 (?),0x09 (?),0x0A (?),0x0B (?),0x0C (?),0x0D (?),0x0E (?),0x0F (?),0x10 (?),0x11 (?),0x12 (?),0x13 (?),0x14 (?),0x15 (?),0x16 (?),0x17 (?),0x18 (?),0x19 (?),0x1A (?),0x1B (?),0x1C (?),0x1D (?),0x1E (?),0x1F (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00584A3C$ PER_TESLA9X45_Part5.per -queue SNOC_TPRB2_SPROF_COUNTERS_13_SRC"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00584A40
tree " SNOC_TPRB2_SPROF_COUNTERS_13_ALARMMODE [RW]                       0x00584A40"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x00000003    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_TPRB2_SPROF_COUNTERS_13_ALARMMODE PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   0.--1.       "[1 : 0]    COUNTERS_13_ALARMMODE               = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00584A40$ PER_TESLA9X45_Part5.per -queue SNOC_TPRB2_SPROF_COUNTERS_13_ALARMMODE"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00584A44
tree " SNOC_TPRB2_SPROF_COUNTERS_13_VAL [R]                              0x00584A44"
  group.long 0x0--0x3
   textline "POR 0xDEADBEEF [0xxxxxxxxx]    MASK =  "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_TPRB2_SPROF_COUNTERS_13_VAL PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.word 0 0.--15. 1  "[15 : 0]   COUNTERS_13_VAL                     = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00584A44$ PER_TESLA9X45_Part5.per -queue SNOC_TPRB2_SPROF_COUNTERS_13_VAL"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00584A50
tree " SNOC_TPRB2_SPROF_COUNTERS_14_SRC [RW]                             0x00584A50"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x0000003F    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_TPRB2_SPROF_COUNTERS_14_SRC PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   5.           "[ 5 ]      EXTEVENT                            = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   0.--4.       "[4 : 0]    INTEVENT                            = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?),0x08 (?),0x09 (?),0x0A (?),0x0B (?),0x0C (?),0x0D (?),0x0E (?),0x0F (?),0x10 (?),0x11 (?),0x12 (?),0x13 (?),0x14 (?),0x15 (?),0x16 (?),0x17 (?),0x18 (?),0x19 (?),0x1A (?),0x1B (?),0x1C (?),0x1D (?),0x1E (?),0x1F (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00584A50$ PER_TESLA9X45_Part5.per -queue SNOC_TPRB2_SPROF_COUNTERS_14_SRC"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00584A54
tree " SNOC_TPRB2_SPROF_COUNTERS_14_ALARMMODE [RW]                       0x00584A54"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x00000003    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_TPRB2_SPROF_COUNTERS_14_ALARMMODE PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   0.--1.       "[1 : 0]    COUNTERS_14_ALARMMODE               = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00584A54$ PER_TESLA9X45_Part5.per -queue SNOC_TPRB2_SPROF_COUNTERS_14_ALARMMODE"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00584A58
tree " SNOC_TPRB2_SPROF_COUNTERS_14_VAL [R]                              0x00584A58"
  group.long 0x0--0x3
   textline "POR 0xDEADBEEF [0xxxxxxxxx]    MASK =  "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_TPRB2_SPROF_COUNTERS_14_VAL PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.word 0 0.--15. 1  "[15 : 0]   COUNTERS_14_VAL                     = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00584A58$ PER_TESLA9X45_Part5.per -queue SNOC_TPRB2_SPROF_COUNTERS_14_VAL"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00584A64
tree " SNOC_TPRB2_SPROF_COUNTERS_15_SRC [RW]                             0x00584A64"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x0000003F    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_TPRB2_SPROF_COUNTERS_15_SRC PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   5.           "[ 5 ]      EXTEVENT                            = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   0.--4.       "[4 : 0]    INTEVENT                            = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?),0x08 (?),0x09 (?),0x0A (?),0x0B (?),0x0C (?),0x0D (?),0x0E (?),0x0F (?),0x10 (?),0x11 (?),0x12 (?),0x13 (?),0x14 (?),0x15 (?),0x16 (?),0x17 (?),0x18 (?),0x19 (?),0x1A (?),0x1B (?),0x1C (?),0x1D (?),0x1E (?),0x1F (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00584A64$ PER_TESLA9X45_Part5.per -queue SNOC_TPRB2_SPROF_COUNTERS_15_SRC"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00584A68
tree " SNOC_TPRB2_SPROF_COUNTERS_15_ALARMMODE [RW]                       0x00584A68"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x00000003    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_TPRB2_SPROF_COUNTERS_15_ALARMMODE PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   0.--1.       "[1 : 0]    COUNTERS_15_ALARMMODE               = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00584A68$ PER_TESLA9X45_Part5.per -queue SNOC_TPRB2_SPROF_COUNTERS_15_ALARMMODE"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00584A6C
tree " SNOC_TPRB2_SPROF_COUNTERS_15_VAL [R]                              0x00584A6C"
  group.long 0x0--0x3
   textline "POR 0xDEADBEEF [0xxxxxxxxx]    MASK =  "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_TPRB2_SPROF_COUNTERS_15_VAL PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.word 0 0.--15. 1  "[15 : 0]   COUNTERS_15_VAL                     = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00584A6C$ PER_TESLA9X45_Part5.per -queue SNOC_TPRB2_SPROF_COUNTERS_15_VAL"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00588000
tree " SNOC_MSS_CRYPTO_NAV_DBG_QOS_ID_COREID [R]                         0x00588000"
  group.long 0x0--0x3
   textline "POR 0x83918A04    MASK = 0xFFFFFFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_MSS_CRYPTO_NAV_DBG_QOS_ID_COREID PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.long 0 8.--31. 1  "[31 : 8]   CORECHECKSUM                        = "
   textline ""
   hexmask.long.byte 0 0.--7. 1   "[7 : 0]    CORETYPEID                          = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00588000$ PER_TESLA9X45_Part5.per -queue SNOC_MSS_CRYPTO_NAV_DBG_QOS_ID_COREID"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00588004
tree " SNOC_MSS_CRYPTO_NAV_DBG_QOS_ID_REVISIONID [R]                     0x00588004"
  group.long 0x0--0x3
   textline "POR 0x00049C00    MASK = 0xFFFFFFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_MSS_CRYPTO_NAV_DBG_QOS_ID_REVISIONID PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.long 0 8.--31. 1  "[31 : 8]   FLEXNOCID                           = "
   textline ""
   hexmask.long.byte 0 0.--7. 1   "[7 : 0]    USERID                              = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00588004$ PER_TESLA9X45_Part5.per -queue SNOC_MSS_CRYPTO_NAV_DBG_QOS_ID_REVISIONID"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00588008
tree " SNOC_MSS_CRYPTO_NAV_DBG_QOS_PRIORITY [RW]                         0x00588008"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x0000000F    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_MSS_CRYPTO_NAV_DBG_QOS_PRIORITY PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   2.--3.       "[3 : 2]    P1                                  = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?)"
   textline ""
   bitfld.long 0x0   0.--1.       "[1 : 0]    P0                                  = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00588008$ PER_TESLA9X45_Part5.per -queue SNOC_MSS_CRYPTO_NAV_DBG_QOS_PRIORITY"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0058800C
tree " SNOC_MSS_CRYPTO_NAV_DBG_QOS_MODE [RW]                             0x0058800C"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x00000003    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_MSS_CRYPTO_NAV_DBG_QOS_MODE PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   0.--1.       "[1 : 0]    MODE                                = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0058800C$ PER_TESLA9X45_Part5.per -queue SNOC_MSS_CRYPTO_NAV_DBG_QOS_MODE"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00588018
tree " SNOC_MSS_CRYPTO_NAV_DBG_QOS_EXTCONTROL [RW]                       0x00588018"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x00000007    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_MSS_CRYPTO_NAV_DBG_QOS_EXTCONTROL PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   2.           "[ 2 ]      INTCLKEN                            = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   1.           "[ 1 ]      EXTTHREN                            = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   0.           "[ 0 ]      SOCKETQOSEN                         = " "0x00 (?),0x01 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00588018$ PER_TESLA9X45_Part5.per -queue SNOC_MSS_CRYPTO_NAV_DBG_QOS_EXTCONTROL"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0058C000
tree " SNOC_PCNOC_QOS_ID_COREID [R]                                      0x0058C000"
  group.long 0x0--0x3
   textline "POR 0x5601D904    MASK = 0xFFFFFFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_PCNOC_QOS_ID_COREID PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.long 0 8.--31. 1  "[31 : 8]   CORECHECKSUM                        = "
   textline ""
   hexmask.long.byte 0 0.--7. 1   "[7 : 0]    CORETYPEID                          = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0058C000$ PER_TESLA9X45_Part5.per -queue SNOC_PCNOC_QOS_ID_COREID"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0058C004
tree " SNOC_PCNOC_QOS_ID_REVISIONID [R]                                  0x0058C004"
  group.long 0x0--0x3
   textline "POR 0x00049C00    MASK = 0xFFFFFFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_PCNOC_QOS_ID_REVISIONID PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.long 0 8.--31. 1  "[31 : 8]   FLEXNOCID                           = "
   textline ""
   hexmask.long.byte 0 0.--7. 1   "[7 : 0]    USERID                              = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0058C004$ PER_TESLA9X45_Part5.per -queue SNOC_PCNOC_QOS_ID_REVISIONID"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0058C008
tree " SNOC_PCNOC_QOS_PRIORITY [RW]                                      0x0058C008"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x0000000F    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_PCNOC_QOS_PRIORITY PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   2.--3.       "[3 : 2]    P1                                  = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?)"
   textline ""
   bitfld.long 0x0   0.--1.       "[1 : 0]    P0                                  = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0058C008$ PER_TESLA9X45_Part5.per -queue SNOC_PCNOC_QOS_PRIORITY"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0058C00C
tree " SNOC_PCNOC_QOS_MODE [RW]                                          0x0058C00C"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x00000003    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_PCNOC_QOS_MODE PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   0.--1.       "[1 : 0]    MODE                                = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0058C00C$ PER_TESLA9X45_Part5.per -queue SNOC_PCNOC_QOS_MODE"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0058C018
tree " SNOC_PCNOC_QOS_EXTCONTROL [RW]                                    0x0058C018"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x00000007    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_PCNOC_QOS_EXTCONTROL PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   2.           "[ 2 ]      INTCLKEN                            = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   1.           "[ 1 ]      EXTTHREN                            = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   0.           "[ 0 ]      SOCKETQOSEN                         = " "0x00 (?),0x01 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0058C018$ PER_TESLA9X45_Part5.per -queue SNOC_PCNOC_QOS_EXTCONTROL"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0058D000
tree " SNOC_IPA_QOS_ID_COREID [R]                                        0x0058D000"
  group.long 0x0--0x3
   textline "POR 0xBE9F4804    MASK = 0xFFFFFFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_IPA_QOS_ID_COREID PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.long 0 8.--31. 1  "[31 : 8]   CORECHECKSUM                        = "
   textline ""
   hexmask.long.byte 0 0.--7. 1   "[7 : 0]    CORETYPEID                          = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0058D000$ PER_TESLA9X45_Part5.per -queue SNOC_IPA_QOS_ID_COREID"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0058D004
tree " SNOC_IPA_QOS_ID_REVISIONID [R]                                    0x0058D004"
  group.long 0x0--0x3
   textline "POR 0x00049C00    MASK = 0xFFFFFFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_IPA_QOS_ID_REVISIONID PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.long 0 8.--31. 1  "[31 : 8]   FLEXNOCID                           = "
   textline ""
   hexmask.long.byte 0 0.--7. 1   "[7 : 0]    USERID                              = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0058D004$ PER_TESLA9X45_Part5.per -queue SNOC_IPA_QOS_ID_REVISIONID"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0058D008
tree " SNOC_IPA_QOS_PRIORITY [RW]                                        0x0058D008"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x0000000F    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_IPA_QOS_PRIORITY PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   2.--3.       "[3 : 2]    P1                                  = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?)"
   textline ""
   bitfld.long 0x0   0.--1.       "[1 : 0]    P0                                  = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0058D008$ PER_TESLA9X45_Part5.per -queue SNOC_IPA_QOS_PRIORITY"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0058D00C
tree " SNOC_IPA_QOS_MODE [RW]                                            0x0058D00C"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x00000003    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_IPA_QOS_MODE PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   0.--1.       "[1 : 0]    MODE                                = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0058D00C$ PER_TESLA9X45_Part5.per -queue SNOC_IPA_QOS_MODE"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0058D018
tree " SNOC_IPA_QOS_EXTCONTROL [RW]                                      0x0058D018"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x00000007    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_IPA_QOS_EXTCONTROL PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   2.           "[ 2 ]      INTCLKEN                            = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   1.           "[ 1 ]      EXTTHREN                            = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   0.           "[ 0 ]      SOCKETQOSEN                         = " "0x00 (?),0x01 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0058D018$ PER_TESLA9X45_Part5.per -queue SNOC_IPA_QOS_EXTCONTROL"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0058E000
tree " SNOC_PCIE_QOS_ID_COREID [R]                                       0x0058E000"
  group.long 0x0--0x3
   textline "POR 0xE3C46004    MASK = 0xFFFFFFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_PCIE_QOS_ID_COREID PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.long 0 8.--31. 1  "[31 : 8]   CORECHECKSUM                        = "
   textline ""
   hexmask.long.byte 0 0.--7. 1   "[7 : 0]    CORETYPEID                          = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0058E000$ PER_TESLA9X45_Part5.per -queue SNOC_PCIE_QOS_ID_COREID"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0058E004
tree " SNOC_PCIE_QOS_ID_REVISIONID [R]                                   0x0058E004"
  group.long 0x0--0x3
   textline "POR 0x00049C00    MASK = 0xFFFFFFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_PCIE_QOS_ID_REVISIONID PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.long 0 8.--31. 1  "[31 : 8]   FLEXNOCID                           = "
   textline ""
   hexmask.long.byte 0 0.--7. 1   "[7 : 0]    USERID                              = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0058E004$ PER_TESLA9X45_Part5.per -queue SNOC_PCIE_QOS_ID_REVISIONID"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0058E008
tree " SNOC_PCIE_QOS_PRIORITY [RW]                                       0x0058E008"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x0000000F    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_PCIE_QOS_PRIORITY PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   2.--3.       "[3 : 2]    P1                                  = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?)"
   textline ""
   bitfld.long 0x0   0.--1.       "[1 : 0]    P0                                  = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0058E008$ PER_TESLA9X45_Part5.per -queue SNOC_PCIE_QOS_PRIORITY"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0058E00C
tree " SNOC_PCIE_QOS_MODE [RW]                                           0x0058E00C"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x00000003    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_PCIE_QOS_MODE PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   0.--1.       "[1 : 0]    MODE                                = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0058E00C$ PER_TESLA9X45_Part5.per -queue SNOC_PCIE_QOS_MODE"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0058E018
tree " SNOC_PCIE_QOS_EXTCONTROL [RW]                                     0x0058E018"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x00000007    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_PCIE_QOS_EXTCONTROL PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   2.           "[ 2 ]      INTCLKEN                            = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   1.           "[ 1 ]      EXTTHREN                            = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   0.           "[ 0 ]      SOCKETQOSEN                         = " "0x00 (?),0x01 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0058E018$ PER_TESLA9X45_Part5.per -queue SNOC_PCIE_QOS_EXTCONTROL"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0058F000
tree " SNOC_USB3_QOS_ID_COREID [R]                                       0x0058F000"
  group.long 0x0--0x3
   textline "POR 0xDA113C04    MASK = 0xFFFFFFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_USB3_QOS_ID_COREID PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.long 0 8.--31. 1  "[31 : 8]   CORECHECKSUM                        = "
   textline ""
   hexmask.long.byte 0 0.--7. 1   "[7 : 0]    CORETYPEID                          = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0058F000$ PER_TESLA9X45_Part5.per -queue SNOC_USB3_QOS_ID_COREID"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0058F004
tree " SNOC_USB3_QOS_ID_REVISIONID [R]                                   0x0058F004"
  group.long 0x0--0x3
   textline "POR 0x00049C00    MASK = 0xFFFFFFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_USB3_QOS_ID_REVISIONID PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.long 0 8.--31. 1  "[31 : 8]   FLEXNOCID                           = "
   textline ""
   hexmask.long.byte 0 0.--7. 1   "[7 : 0]    USERID                              = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0058F004$ PER_TESLA9X45_Part5.per -queue SNOC_USB3_QOS_ID_REVISIONID"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0058F008
tree " SNOC_USB3_QOS_PRIORITY [RW]                                       0x0058F008"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x0000000F    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_USB3_QOS_PRIORITY PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   2.--3.       "[3 : 2]    P1                                  = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?)"
   textline ""
   bitfld.long 0x0   0.--1.       "[1 : 0]    P0                                  = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0058F008$ PER_TESLA9X45_Part5.per -queue SNOC_USB3_QOS_PRIORITY"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0058F00C
tree " SNOC_USB3_QOS_MODE [RW]                                           0x0058F00C"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x00000003    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_USB3_QOS_MODE PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   0.--1.       "[1 : 0]    MODE                                = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0058F00C$ PER_TESLA9X45_Part5.per -queue SNOC_USB3_QOS_MODE"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0058F018
tree " SNOC_USB3_QOS_EXTCONTROL [RW]                                     0x0058F018"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x00000007    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_USB3_QOS_EXTCONTROL PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   2.           "[ 2 ]      INTCLKEN                            = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   1.           "[ 1 ]      EXTTHREN                            = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   0.           "[ 0 ]      SOCKETQOSEN                         = " "0x00 (?),0x01 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0058F018$ PER_TESLA9X45_Part5.per -queue SNOC_USB3_QOS_EXTCONTROL"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00592000
tree " SNOC_QDSS_ETR_QOS_ID_COREID [R]                                   0x00592000"
  group.long 0x0--0x3
   textline "POR 0x56E09B04    MASK = 0xFFFFFFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_QDSS_ETR_QOS_ID_COREID PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.long 0 8.--31. 1  "[31 : 8]   CORECHECKSUM                        = "
   textline ""
   hexmask.long.byte 0 0.--7. 1   "[7 : 0]    CORETYPEID                          = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00592000$ PER_TESLA9X45_Part5.per -queue SNOC_QDSS_ETR_QOS_ID_COREID"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00592004
tree " SNOC_QDSS_ETR_QOS_ID_REVISIONID [R]                               0x00592004"
  group.long 0x0--0x3
   textline "POR 0x00049C00    MASK = 0xFFFFFFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_QDSS_ETR_QOS_ID_REVISIONID PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.long 0 8.--31. 1  "[31 : 8]   FLEXNOCID                           = "
   textline ""
   hexmask.long.byte 0 0.--7. 1   "[7 : 0]    USERID                              = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00592004$ PER_TESLA9X45_Part5.per -queue SNOC_QDSS_ETR_QOS_ID_REVISIONID"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00592008
tree " SNOC_QDSS_ETR_QOS_PRIORITY [RW]                                   0x00592008"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x0000000F    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_QDSS_ETR_QOS_PRIORITY PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   2.--3.       "[3 : 2]    P1                                  = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?)"
   textline ""
   bitfld.long 0x0   0.--1.       "[1 : 0]    P0                                  = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00592008$ PER_TESLA9X45_Part5.per -queue SNOC_QDSS_ETR_QOS_PRIORITY"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0059200C
tree " SNOC_QDSS_ETR_QOS_MODE [RW]                                       0x0059200C"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x00000003    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_QDSS_ETR_QOS_MODE PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   0.--1.       "[1 : 0]    MODE                                = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0059200C$ PER_TESLA9X45_Part5.per -queue SNOC_QDSS_ETR_QOS_MODE"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00592018
tree " SNOC_QDSS_ETR_QOS_EXTCONTROL [RW]                                 0x00592018"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x00000007    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_QDSS_ETR_QOS_EXTCONTROL PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   2.           "[ 2 ]      INTCLKEN                            = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   1.           "[ 1 ]      EXTTHREN                            = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   0.           "[ 0 ]      SOCKETQOSEN                         = " "0x00 (?),0x01 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00592018$ PER_TESLA9X45_Part5.per -queue SNOC_QDSS_ETR_QOS_EXTCONTROL"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00593000
tree " SNOC_QDSS_BAM_QOS_ID_COREID [R]                                   0x00593000"
  group.long 0x0--0x3
   textline "POR 0x5C3FCD04    MASK = 0xFFFFFFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_QDSS_BAM_QOS_ID_COREID PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.long 0 8.--31. 1  "[31 : 8]   CORECHECKSUM                        = "
   textline ""
   hexmask.long.byte 0 0.--7. 1   "[7 : 0]    CORETYPEID                          = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00593000$ PER_TESLA9X45_Part5.per -queue SNOC_QDSS_BAM_QOS_ID_COREID"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00593004
tree " SNOC_QDSS_BAM_QOS_ID_REVISIONID [R]                               0x00593004"
  group.long 0x0--0x3
   textline "POR 0x00049C00    MASK = 0xFFFFFFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_QDSS_BAM_QOS_ID_REVISIONID PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.long 0 8.--31. 1  "[31 : 8]   FLEXNOCID                           = "
   textline ""
   hexmask.long.byte 0 0.--7. 1   "[7 : 0]    USERID                              = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00593004$ PER_TESLA9X45_Part5.per -queue SNOC_QDSS_BAM_QOS_ID_REVISIONID"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00593008
tree " SNOC_QDSS_BAM_QOS_PRIORITY [RW]                                   0x00593008"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x0000000F    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_QDSS_BAM_QOS_PRIORITY PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   2.--3.       "[3 : 2]    P1                                  = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?)"
   textline ""
   bitfld.long 0x0   0.--1.       "[1 : 0]    P0                                  = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00593008$ PER_TESLA9X45_Part5.per -queue SNOC_QDSS_BAM_QOS_PRIORITY"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0059300C
tree " SNOC_QDSS_BAM_QOS_MODE [RW]                                       0x0059300C"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x00000003    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_QDSS_BAM_QOS_MODE PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   0.--1.       "[1 : 0]    MODE                                = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0059300C$ PER_TESLA9X45_Part5.per -queue SNOC_QDSS_BAM_QOS_MODE"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00593018
tree " SNOC_QDSS_BAM_QOS_EXTCONTROL [RW]                                 0x00593018"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x00000007    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print SNOC_QDSS_BAM_QOS_EXTCONTROL PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   2.           "[ 2 ]      INTCLKEN                            = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   1.           "[ 1 ]      EXTTHREN                            = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   0.           "[ 0 ]      SOCKETQOSEN                         = " "0x00 (?),0x01 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00593018$ PER_TESLA9X45_Part5.per -queue SNOC_QDSS_BAM_QOS_EXTCONTROL"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0002E000
tree " XPU_CFG_PCNOC_CFG_XPU_SCR [RW]                                    0x0002E000"
  group.long 0x0--0x3
   textline "POR 0x00000106    MASK = 0x0000077F    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print XPU_CFG_PCNOC_CFG_XPU_SCR PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   10.          "[ 10 ]     SCLEIE                              = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   9.           "[ 9 ]      SCFGEIE                             = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   8.           "[ 8 ]      DYNAMIC_CLK_EN                      = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   6.           "[ 6 ]      NSRGCLEE                            = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   5.           "[ 5 ]      NSCFGE                              = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   4.           "[ 4 ]      SDCDEE                              = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   3.           "[ 3 ]      SEIE                                = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   2.           "[ 2 ]      SCLERE                              = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   1.           "[ 1 ]      SCFGERE                             = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   0.           "[ 0 ]      XPUNSE                              = " "0x00 (?),0x01 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0002E000$ PER_TESLA9X45_Part5.per -queue XPU_CFG_PCNOC_CFG_XPU_SCR"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0002E004
tree " XPU_CFG_PCNOC_CFG_XPU_SWDR [RW]                                   0x0002E004"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x00000001    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print XPU_CFG_PCNOC_CFG_XPU_SWDR PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   0.           "[ 0 ]      SCFGWD                              = " "0x00 (?),0x01 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0002E004$ PER_TESLA9X45_Part5.per -queue XPU_CFG_PCNOC_CFG_XPU_SWDR"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0002E008
tree " XPU_CFG_PCNOC_CFG_XPU_PRTN_RACR_SSHADOW [RW]                      0x0002E008"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0xFFFFFFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print XPU_CFG_PCNOC_CFG_XPU_PRTN_RACR_SSHADOW PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.long 0 0.--31. 1  "[31 : 0]   RE                                  = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0002E008$ PER_TESLA9X45_Part5.per -queue XPU_CFG_PCNOC_CFG_XPU_PRTN_RACR_SSHADOW"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0002E00C
tree " XPU_CFG_PCNOC_CFG_XPU_PRTN_WACR_SSHADOW [RW]                      0x0002E00C"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0xFFFFFFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print XPU_CFG_PCNOC_CFG_XPU_PRTN_WACR_SSHADOW PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.long 0 0.--31. 1  "[31 : 0]   WE                                  = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0002E00C$ PER_TESLA9X45_Part5.per -queue XPU_CFG_PCNOC_CFG_XPU_PRTN_WACR_SSHADOW"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0002E010
tree " XPU_CFG_PCNOC_CFG_XPU_PRTN_START_SSHADOW0 [RW]                    0x0002E010"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x000FF000    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print XPU_CFG_PCNOC_CFG_XPU_PRTN_START_SSHADOW0 PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.byte 0 12.--19. 1 "[19 : 12]  ADDR                                = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0002E010$ PER_TESLA9X45_Part5.per -queue XPU_CFG_PCNOC_CFG_XPU_PRTN_START_SSHADOW0"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0002E018
tree " XPU_CFG_PCNOC_CFG_XPU_PRTN_END_SSHADOW0 [RW]                      0x0002E018"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x000FF000    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print XPU_CFG_PCNOC_CFG_XPU_PRTN_END_SSHADOW0 PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.byte 0 12.--19. 1 "[19 : 12]  ADDR                                = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0002E018$ PER_TESLA9X45_Part5.per -queue XPU_CFG_PCNOC_CFG_XPU_PRTN_END_SSHADOW0"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0002E040
tree " XPU_CFG_PCNOC_CFG_XPU_SEAR0 [R]                                   0x0002E040"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0xFFFFFFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print XPU_CFG_PCNOC_CFG_XPU_SEAR0 PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.long 0 0.--31. 1  "[31 : 0]   PA                                  = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0002E040$ PER_TESLA9X45_Part5.per -queue XPU_CFG_PCNOC_CFG_XPU_SEAR0"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0002E048
tree " XPU_CFG_PCNOC_CFG_XPU_SESR [RW]                                   0x0002E048"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x8000000F    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print XPU_CFG_PCNOC_CFG_XPU_SESR PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   31.          "[ 31 ]     MULTI                               = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   3.           "[ 3 ]      CLMULTI                             = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   2.           "[ 2 ]      CFGMULTI                            = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   1.           "[ 1 ]      CLIENT                              = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   0.           "[ 0 ]      CFG                                 = " "0x00 (?),0x01 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0002E048$ PER_TESLA9X45_Part5.per -queue XPU_CFG_PCNOC_CFG_XPU_SESR"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0002E04C
tree " XPU_CFG_PCNOC_CFG_XPU_SESRRESTORE [RW]                            0x0002E04C"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x8000000F    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print XPU_CFG_PCNOC_CFG_XPU_SESRRESTORE PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   31.          "[ 31 ]     MULTI                               = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   3.           "[ 3 ]      CLMULTI                             = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   2.           "[ 2 ]      CFGMULTI                            = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   1.           "[ 1 ]      CLIENT                              = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   0.           "[ 0 ]      CFG                                 = " "0x00 (?),0x01 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0002E04C$ PER_TESLA9X45_Part5.per -queue XPU_CFG_PCNOC_CFG_XPU_SESRRESTORE"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0002E050
tree " XPU_CFG_PCNOC_CFG_XPU_SESYNR0 [R]                                 0x0002E050"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0xFFFFFFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print XPU_CFG_PCNOC_CFG_XPU_SESYNR0 PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.byte 0 24.--31. 1 "[31 : 24]  ATID                                = "
   textline ""
   hexmask.long.byte 0 16.--23. 1 "[23 : 16]  AVMID                               = "
   textline ""
   bitfld.long 0x0   13.--15.     "[15 : 13]  ABID                                = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?)"
   textline ""
   bitfld.long 0x0   8.--12.      "[12 : 8]   APID                                = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?),0x08 (?),0x09 (?),0x0A (?),0x0B (?),0x0C (?),0x0D (?),0x0E (?),0x0F (?),0x10 (?),0x11 (?),0x12 (?),0x13 (?),0x14 (?),0x15 (?),0x16 (?),0x17 (?),0x18 (?),0x19 (?),0x1A (?),0x1B (?),0x1C (?),0x1D (?),0x1E (?),0x1F (?)"
   textline ""
   hexmask.long.byte 0 0.--7. 1   "[7 : 0]    AMID                                = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0002E050$ PER_TESLA9X45_Part5.per -queue XPU_CFG_PCNOC_CFG_XPU_SESYNR0"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0002E054
tree " XPU_CFG_PCNOC_CFG_XPU_SESYNR1 [R]                                 0x0002E054"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0xFFFFFFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print XPU_CFG_PCNOC_CFG_XPU_SESYNR1 PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   31.          "[ 31 ]     DCD                                 = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   30.          "[ 30 ]     AC                                  = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   29.          "[ 29 ]     BURSTLEN                            = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   28.          "[ 28 ]     ARDALLOCATE                         = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   27.          "[ 27 ]     ABURST                              = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   26.          "[ 26 ]     AEXCLUSIVE                          = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   25.          "[ 25 ]     AWRITE                              = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   24.          "[ 24 ]     AFULL                               = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   23.          "[ 23 ]     ARDBEADNDXEN                        = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   22.          "[ 22 ]     AOOO                                = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   19.--21.     "[21 : 19]  APREQPRIORITY                       = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?)"
   textline ""
   bitfld.long 0x0   16.--18.     "[18 : 16]  ASIZE                               = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?)"
   textline ""
   bitfld.long 0x0   15.          "[ 15 ]     AMSSSELFAUTH                        = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   8.--14.      "[14 : 8]   ALEN                                = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?),0x08 (?),0x09 (?),0x0A (?),0x0B (?),0x0C (?),0x0D (?),0x0E (?),0x0F (?),0x10 (?),0x11 (?),0x12 (?),0x13 (?),0x14 (?),0x15 (?),0x16 (?),0x17 (?),0x18 (?),0x19 (?),0x1A (?),0x1B (?),0x1C (?),0x1D (?),0x1E (?),0x1F (?),0x20 (?),0x21 (?),0x22 (?),0x23 (?),0x24 (?),0x25 (?),0x26 (?),0x27 (?),0x28 (?),0x29 (?),0x2A (?),0x2B (?),0x2C (?),0x2D (?),0x2E (?),0x2F (?),0x30 (?),0x31 (?),0x32 (?),0x33 (?),0x34 (?),0x35 (?),0x36 (?),0x37 (?),0x38 (?),0x39 (?),0x3A (?),0x3B (?),0x3C (?),0x3D (?),0x3E (?),0x3F (?),0x40 (?),0x41 (?),0x42 (?),0x43 (?),0x44 (?),0x45 (?),0x46 (?),0x47 (?),0x48 (?),0x49 (?),0x4A (?),0x4B (?),0x4C (?),0x4D (?),0x4E (?),0x4F (?),0x50 (?),0x51 (?),0x52 (?),0x53 (?),0x54 (?),0x55 (?),0x56 (?),0x57 (?),0x58 (?),0x59 (?),0x5A (?),0x5B (?),0x5C (?),0x5D (?),0x5E (?),0x5F (?),0x60 (?),0x61 (?),0x62 (?),0x63 (?),0x64 (?),0x65 (?),0x66 (?),0x67 (?),0x68 (?),0x69 (?),0x6A (?),0x6B (?),0x6C (?),0x6D (?),0x6E (?),0x6F (?),0x70 (?),0x71 (?),0x72 (?),0x73 (?),0x74 (?),0x75 (?),0x76 (?),0x77 (?),0x78 (?),0x79 (?),0x7A (?),0x7B (?),0x7C (?),0x7D (?),0x7E (?),0x7F (?)"
   textline ""
   bitfld.long 0x0   7.           "[ 7 ]      AINST                               = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   6.           "[ 6 ]      APROTNS                             = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   5.           "[ 5 ]      APRIV                               = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   4.           "[ 4 ]      AINNERSHARED                        = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   3.           "[ 3 ]      ASHARED                             = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   0.--2.       "[2 : 0]    AMEMTYPE                            = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0002E054$ PER_TESLA9X45_Part5.per -queue XPU_CFG_PCNOC_CFG_XPU_SESYNR1"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0002E058
tree " XPU_CFG_PCNOC_CFG_XPU_SESYNR2 [R]                                 0x0002E058"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x00000007    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print XPU_CFG_PCNOC_CFG_XPU_SESYNR2 PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   2.           "[ 2 ]      MODEM_PRT_HIT                       = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   1.           "[ 1 ]      SECURE_PRT_HIT                      = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   0.           "[ 0 ]      NONSECURE_PRT_HIT                   = " "0x00 (?),0x01 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0002E058$ PER_TESLA9X45_Part5.per -queue XPU_CFG_PCNOC_CFG_XPU_SESYNR2"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0002E100
tree " XPU_CFG_PCNOC_CFG_XPU_MCR [RW]                                    0x0002E100"
  group.long 0x0--0x3
   textline "POR 0x00000106    MASK = 0x0000071F    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print XPU_CFG_PCNOC_CFG_XPU_MCR PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   10.          "[ 10 ]     CLEIE                               = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   9.           "[ 9 ]      CFGEIE                              = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   8.           "[ 8 ]      DYNAMIC_CLK_EN                      = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   4.           "[ 4 ]      DCDEE                               = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   3.           "[ 3 ]      EIE                                 = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   2.           "[ 2 ]      CLERE                               = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   1.           "[ 1 ]      CFGERE                              = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   0.           "[ 0 ]      XPUMSAE                             = " "0x00 (?),0x01 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0002E100$ PER_TESLA9X45_Part5.per -queue XPU_CFG_PCNOC_CFG_XPU_MCR"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0002E140
tree " XPU_CFG_PCNOC_CFG_XPU_MEAR0 [R]                                   0x0002E140"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0xFFFFFFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print XPU_CFG_PCNOC_CFG_XPU_MEAR0 PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.long 0 0.--31. 1  "[31 : 0]   PA                                  = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0002E140$ PER_TESLA9X45_Part5.per -queue XPU_CFG_PCNOC_CFG_XPU_MEAR0"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0002E148
tree " XPU_CFG_PCNOC_CFG_XPU_MESR [RW]                                   0x0002E148"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x8000000F    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print XPU_CFG_PCNOC_CFG_XPU_MESR PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   31.          "[ 31 ]     MULTI                               = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   3.           "[ 3 ]      CLMULTI                             = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   2.           "[ 2 ]      CFGMULTI                            = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   1.           "[ 1 ]      CLIENT                              = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   0.           "[ 0 ]      CFG                                 = " "0x00 (?),0x01 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0002E148$ PER_TESLA9X45_Part5.per -queue XPU_CFG_PCNOC_CFG_XPU_MESR"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0002E14C
tree " XPU_CFG_PCNOC_CFG_XPU_MESRRESTORE [RW]                            0x0002E14C"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x8000000F    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print XPU_CFG_PCNOC_CFG_XPU_MESRRESTORE PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   31.          "[ 31 ]     MULTI                               = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   3.           "[ 3 ]      CLMULTI                             = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   2.           "[ 2 ]      CFGMULTI                            = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   1.           "[ 1 ]      CLIENT                              = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   0.           "[ 0 ]      CFG                                 = " "0x00 (?),0x01 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0002E14C$ PER_TESLA9X45_Part5.per -queue XPU_CFG_PCNOC_CFG_XPU_MESRRESTORE"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0002E150
tree " XPU_CFG_PCNOC_CFG_XPU_MESYNR0 [R]                                 0x0002E150"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0xFFFFFFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print XPU_CFG_PCNOC_CFG_XPU_MESYNR0 PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.byte 0 24.--31. 1 "[31 : 24]  ATID                                = "
   textline ""
   hexmask.long.byte 0 16.--23. 1 "[23 : 16]  AVMID                               = "
   textline ""
   bitfld.long 0x0   13.--15.     "[15 : 13]  ABID                                = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?)"
   textline ""
   bitfld.long 0x0   8.--12.      "[12 : 8]   APID                                = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?),0x08 (?),0x09 (?),0x0A (?),0x0B (?),0x0C (?),0x0D (?),0x0E (?),0x0F (?),0x10 (?),0x11 (?),0x12 (?),0x13 (?),0x14 (?),0x15 (?),0x16 (?),0x17 (?),0x18 (?),0x19 (?),0x1A (?),0x1B (?),0x1C (?),0x1D (?),0x1E (?),0x1F (?)"
   textline ""
   hexmask.long.byte 0 0.--7. 1   "[7 : 0]    AMID                                = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0002E150$ PER_TESLA9X45_Part5.per -queue XPU_CFG_PCNOC_CFG_XPU_MESYNR0"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0002E154
tree " XPU_CFG_PCNOC_CFG_XPU_MESYNR1 [R]                                 0x0002E154"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0xFFFFFFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print XPU_CFG_PCNOC_CFG_XPU_MESYNR1 PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   31.          "[ 31 ]     DCD                                 = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   30.          "[ 30 ]     AC                                  = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   29.          "[ 29 ]     BURSTLEN                            = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   28.          "[ 28 ]     ARDALLOCATE                         = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   27.          "[ 27 ]     ABURST                              = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   26.          "[ 26 ]     AEXCLUSIVE                          = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   25.          "[ 25 ]     AWRITE                              = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   24.          "[ 24 ]     AFULL                               = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   23.          "[ 23 ]     ARDBEADNDXEN                        = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   22.          "[ 22 ]     AOOO                                = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   19.--21.     "[21 : 19]  APREQPRIORITY                       = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?)"
   textline ""
   bitfld.long 0x0   16.--18.     "[18 : 16]  ASIZE                               = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?)"
   textline ""
   bitfld.long 0x0   15.          "[ 15 ]     AMSSSELFAUTH                        = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   8.--14.      "[14 : 8]   ALEN                                = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?),0x08 (?),0x09 (?),0x0A (?),0x0B (?),0x0C (?),0x0D (?),0x0E (?),0x0F (?),0x10 (?),0x11 (?),0x12 (?),0x13 (?),0x14 (?),0x15 (?),0x16 (?),0x17 (?),0x18 (?),0x19 (?),0x1A (?),0x1B (?),0x1C (?),0x1D (?),0x1E (?),0x1F (?),0x20 (?),0x21 (?),0x22 (?),0x23 (?),0x24 (?),0x25 (?),0x26 (?),0x27 (?),0x28 (?),0x29 (?),0x2A (?),0x2B (?),0x2C (?),0x2D (?),0x2E (?),0x2F (?),0x30 (?),0x31 (?),0x32 (?),0x33 (?),0x34 (?),0x35 (?),0x36 (?),0x37 (?),0x38 (?),0x39 (?),0x3A (?),0x3B (?),0x3C (?),0x3D (?),0x3E (?),0x3F (?),0x40 (?),0x41 (?),0x42 (?),0x43 (?),0x44 (?),0x45 (?),0x46 (?),0x47 (?),0x48 (?),0x49 (?),0x4A (?),0x4B (?),0x4C (?),0x4D (?),0x4E (?),0x4F (?),0x50 (?),0x51 (?),0x52 (?),0x53 (?),0x54 (?),0x55 (?),0x56 (?),0x57 (?),0x58 (?),0x59 (?),0x5A (?),0x5B (?),0x5C (?),0x5D (?),0x5E (?),0x5F (?),0x60 (?),0x61 (?),0x62 (?),0x63 (?),0x64 (?),0x65 (?),0x66 (?),0x67 (?),0x68 (?),0x69 (?),0x6A (?),0x6B (?),0x6C (?),0x6D (?),0x6E (?),0x6F (?),0x70 (?),0x71 (?),0x72 (?),0x73 (?),0x74 (?),0x75 (?),0x76 (?),0x77 (?),0x78 (?),0x79 (?),0x7A (?),0x7B (?),0x7C (?),0x7D (?),0x7E (?),0x7F (?)"
   textline ""
   bitfld.long 0x0   7.           "[ 7 ]      AINST                               = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   6.           "[ 6 ]      APROTNS                             = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   5.           "[ 5 ]      APRIV                               = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   4.           "[ 4 ]      AINNERSHARED                        = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   3.           "[ 3 ]      ASHARED                             = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   0.--2.       "[2 : 0]    AMEMTYPE                            = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0002E154$ PER_TESLA9X45_Part5.per -queue XPU_CFG_PCNOC_CFG_XPU_MESYNR1"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0002E158
tree " XPU_CFG_PCNOC_CFG_XPU_MESYNR2 [R]                                 0x0002E158"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x00000007    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print XPU_CFG_PCNOC_CFG_XPU_MESYNR2 PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   2.           "[ 2 ]      MODEM_PRT_HIT                       = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   1.           "[ 1 ]      SECURE_PRT_HIT                      = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   0.           "[ 0 ]      NONSECURE_PRT_HIT                   = " "0x00 (?),0x01 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0002E158$ PER_TESLA9X45_Part5.per -queue XPU_CFG_PCNOC_CFG_XPU_MESYNR2"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0002E080
tree " XPU_CFG_PCNOC_CFG_XPU_CR [RW]                                     0x0002E080"
  group.long 0x0--0x3
   textline "POR 0x00000106    MASK = 0x0001071F    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print XPU_CFG_PCNOC_CFG_XPU_CR PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   16.          "[ 16 ]     MSAE                                = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   10.          "[ 10 ]     CLEIE                               = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   9.           "[ 9 ]      CFGEIE                              = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   8.           "[ 8 ]      DYNAMIC_CLK_EN                      = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   4.           "[ 4 ]      DCDEE                               = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   3.           "[ 3 ]      EIE                                 = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   2.           "[ 2 ]      CLERE                               = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   1.           "[ 1 ]      CFGERE                              = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   0.           "[ 0 ]      XPUVMIDE                            = " "0x00 (?),0x01 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0002E080$ PER_TESLA9X45_Part5.per -queue XPU_CFG_PCNOC_CFG_XPU_CR"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0002E088
tree " XPU_CFG_PCNOC_CFG_XPU_PRTN_RACR_SHADOW [RW]                       0x0002E088"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0xFFFFFFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print XPU_CFG_PCNOC_CFG_XPU_PRTN_RACR_SHADOW PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.long 0 0.--31. 1  "[31 : 0]   RE                                  = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0002E088$ PER_TESLA9X45_Part5.per -queue XPU_CFG_PCNOC_CFG_XPU_PRTN_RACR_SHADOW"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0002E08C
tree " XPU_CFG_PCNOC_CFG_XPU_PRTN_WACR_SHADOW [RW]                       0x0002E08C"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0xFFFFFFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print XPU_CFG_PCNOC_CFG_XPU_PRTN_WACR_SHADOW PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.long 0 0.--31. 1  "[31 : 0]   WE                                  = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0002E08C$ PER_TESLA9X45_Part5.per -queue XPU_CFG_PCNOC_CFG_XPU_PRTN_WACR_SHADOW"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0002E090
tree " XPU_CFG_PCNOC_CFG_XPU_PRTN_START_SHADOW0 [RW]                     0x0002E090"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x000FF000    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print XPU_CFG_PCNOC_CFG_XPU_PRTN_START_SHADOW0 PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.byte 0 12.--19. 1 "[19 : 12]  ADDR                                = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0002E090$ PER_TESLA9X45_Part5.per -queue XPU_CFG_PCNOC_CFG_XPU_PRTN_START_SHADOW0"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0002E098
tree " XPU_CFG_PCNOC_CFG_XPU_PRTN_END_SHADOW0 [RW]                       0x0002E098"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x000FF000    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print XPU_CFG_PCNOC_CFG_XPU_PRTN_END_SHADOW0 PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.byte 0 12.--19. 1 "[19 : 12]  ADDR                                = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0002E098$ PER_TESLA9X45_Part5.per -queue XPU_CFG_PCNOC_CFG_XPU_PRTN_END_SHADOW0"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0002E0A0
tree " XPU_CFG_PCNOC_CFG_XPU_RPU_ACR0 [RW] n[0:0]                        0x0002E0A0"
  group.long 0x0--0x3
   textline "POR 0xFFFFFFFF    MASK = 0xFFFFFFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print XPU_CFG_PCNOC_CFG_XPU_RPU_ACR0 PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.long 0 0.--31. 1  "[31 : 0]   RWE                                 = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0002E0A0$ PER_TESLA9X45_Part5.per -queue XPU_CFG_PCNOC_CFG_XPU_RPU_ACR0"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0002E0C0
tree " XPU_CFG_PCNOC_CFG_XPU_EAR0 [R]                                    0x0002E0C0"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0xFFFFFFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print XPU_CFG_PCNOC_CFG_XPU_EAR0 PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.long 0 0.--31. 1  "[31 : 0]   PA                                  = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0002E0C0$ PER_TESLA9X45_Part5.per -queue XPU_CFG_PCNOC_CFG_XPU_EAR0"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0002E0C8
tree " XPU_CFG_PCNOC_CFG_XPU_ESR [RW]                                    0x0002E0C8"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x8000000F    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print XPU_CFG_PCNOC_CFG_XPU_ESR PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   31.          "[ 31 ]     MULTI                               = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   3.           "[ 3 ]      CLMULTI                             = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   2.           "[ 2 ]      CFGMULTI                            = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   1.           "[ 1 ]      CLIENT                              = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   0.           "[ 0 ]      CFG                                 = " "0x00 (?),0x01 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0002E0C8$ PER_TESLA9X45_Part5.per -queue XPU_CFG_PCNOC_CFG_XPU_ESR"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0002E0CC
tree " XPU_CFG_PCNOC_CFG_XPU_ESRRESTORE [RW]                             0x0002E0CC"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x8000000F    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print XPU_CFG_PCNOC_CFG_XPU_ESRRESTORE PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   31.          "[ 31 ]     MULTI                               = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   3.           "[ 3 ]      CLMULTI                             = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   2.           "[ 2 ]      CFGMULTI                            = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   1.           "[ 1 ]      CLIENT                              = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   0.           "[ 0 ]      CFG                                 = " "0x00 (?),0x01 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0002E0CC$ PER_TESLA9X45_Part5.per -queue XPU_CFG_PCNOC_CFG_XPU_ESRRESTORE"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0002E0D0
tree " XPU_CFG_PCNOC_CFG_XPU_ESYNR0 [R]                                  0x0002E0D0"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0xFFFFFFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print XPU_CFG_PCNOC_CFG_XPU_ESYNR0 PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.byte 0 24.--31. 1 "[31 : 24]  ATID                                = "
   textline ""
   hexmask.long.byte 0 16.--23. 1 "[23 : 16]  AVMID                               = "
   textline ""
   bitfld.long 0x0   13.--15.     "[15 : 13]  ABID                                = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?)"
   textline ""
   bitfld.long 0x0   8.--12.      "[12 : 8]   APID                                = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?),0x08 (?),0x09 (?),0x0A (?),0x0B (?),0x0C (?),0x0D (?),0x0E (?),0x0F (?),0x10 (?),0x11 (?),0x12 (?),0x13 (?),0x14 (?),0x15 (?),0x16 (?),0x17 (?),0x18 (?),0x19 (?),0x1A (?),0x1B (?),0x1C (?),0x1D (?),0x1E (?),0x1F (?)"
   textline ""
   hexmask.long.byte 0 0.--7. 1   "[7 : 0]    AMID                                = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0002E0D0$ PER_TESLA9X45_Part5.per -queue XPU_CFG_PCNOC_CFG_XPU_ESYNR0"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0002E0D4
tree " XPU_CFG_PCNOC_CFG_XPU_ESYNR1 [R]                                  0x0002E0D4"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0xFFFFFFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print XPU_CFG_PCNOC_CFG_XPU_ESYNR1 PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   31.          "[ 31 ]     DCD                                 = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   30.          "[ 30 ]     AC                                  = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   29.          "[ 29 ]     BURSTLEN                            = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   28.          "[ 28 ]     ARDALLOCATE                         = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   27.          "[ 27 ]     ABURST                              = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   26.          "[ 26 ]     AEXCLUSIVE                          = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   25.          "[ 25 ]     AWRITE                              = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   24.          "[ 24 ]     AFULL                               = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   23.          "[ 23 ]     ARDBEADNDXEN                        = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   22.          "[ 22 ]     AOOO                                = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   19.--21.     "[21 : 19]  APREQPRIORITY                       = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?)"
   textline ""
   bitfld.long 0x0   16.--18.     "[18 : 16]  ASIZE                               = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?)"
   textline ""
   bitfld.long 0x0   15.          "[ 15 ]     AMSSSELFAUTH                        = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   8.--14.      "[14 : 8]   ALEN                                = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?),0x08 (?),0x09 (?),0x0A (?),0x0B (?),0x0C (?),0x0D (?),0x0E (?),0x0F (?),0x10 (?),0x11 (?),0x12 (?),0x13 (?),0x14 (?),0x15 (?),0x16 (?),0x17 (?),0x18 (?),0x19 (?),0x1A (?),0x1B (?),0x1C (?),0x1D (?),0x1E (?),0x1F (?),0x20 (?),0x21 (?),0x22 (?),0x23 (?),0x24 (?),0x25 (?),0x26 (?),0x27 (?),0x28 (?),0x29 (?),0x2A (?),0x2B (?),0x2C (?),0x2D (?),0x2E (?),0x2F (?),0x30 (?),0x31 (?),0x32 (?),0x33 (?),0x34 (?),0x35 (?),0x36 (?),0x37 (?),0x38 (?),0x39 (?),0x3A (?),0x3B (?),0x3C (?),0x3D (?),0x3E (?),0x3F (?),0x40 (?),0x41 (?),0x42 (?),0x43 (?),0x44 (?),0x45 (?),0x46 (?),0x47 (?),0x48 (?),0x49 (?),0x4A (?),0x4B (?),0x4C (?),0x4D (?),0x4E (?),0x4F (?),0x50 (?),0x51 (?),0x52 (?),0x53 (?),0x54 (?),0x55 (?),0x56 (?),0x57 (?),0x58 (?),0x59 (?),0x5A (?),0x5B (?),0x5C (?),0x5D (?),0x5E (?),0x5F (?),0x60 (?),0x61 (?),0x62 (?),0x63 (?),0x64 (?),0x65 (?),0x66 (?),0x67 (?),0x68 (?),0x69 (?),0x6A (?),0x6B (?),0x6C (?),0x6D (?),0x6E (?),0x6F (?),0x70 (?),0x71 (?),0x72 (?),0x73 (?),0x74 (?),0x75 (?),0x76 (?),0x77 (?),0x78 (?),0x79 (?),0x7A (?),0x7B (?),0x7C (?),0x7D (?),0x7E (?),0x7F (?)"
   textline ""
   bitfld.long 0x0   7.           "[ 7 ]      AINST                               = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   6.           "[ 6 ]      APROTNS                             = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   5.           "[ 5 ]      APRIV                               = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   4.           "[ 4 ]      AINNERSHARED                        = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   3.           "[ 3 ]      ASHARED                             = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   0.--2.       "[2 : 0]    AMEMTYPE                            = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0002E0D4$ PER_TESLA9X45_Part5.per -queue XPU_CFG_PCNOC_CFG_XPU_ESYNR1"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0002E0D8
tree " XPU_CFG_PCNOC_CFG_XPU_ESYNR2 [R]                                  0x0002E0D8"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x00000007    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print XPU_CFG_PCNOC_CFG_XPU_ESYNR2 PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   2.           "[ 2 ]      MODEM_PRT_HIT                       = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   1.           "[ 1 ]      SECURE_PRT_HIT                      = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   0.           "[ 0 ]      NONSECURE_PRT_HIT                   = " "0x00 (?),0x01 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0002E0D8$ PER_TESLA9X45_Part5.per -queue XPU_CFG_PCNOC_CFG_XPU_ESYNR2"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0002E0E0
tree " XPU_CFG_PCNOC_CFG_XPU_UMR_RACR [RW]                               0x0002E0E0"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0xFFFFFFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print XPU_CFG_PCNOC_CFG_XPU_UMR_RACR PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.long 0 0.--31. 1  "[31 : 0]   RE                                  = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0002E0E0$ PER_TESLA9X45_Part5.per -queue XPU_CFG_PCNOC_CFG_XPU_UMR_RACR"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0002E0E4
tree " XPU_CFG_PCNOC_CFG_XPU_UMR_WACR [RW]                               0x0002E0E4"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0xFFFFFFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print XPU_CFG_PCNOC_CFG_XPU_UMR_WACR PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.long 0 0.--31. 1  "[31 : 0]   WE                                  = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0002E0E4$ PER_TESLA9X45_Part5.per -queue XPU_CFG_PCNOC_CFG_XPU_UMR_WACR"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0002E0F0
tree " XPU_CFG_PCNOC_CFG_XPU_UMR_CNTL [RW]                               0x0002E0F0"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x00000003    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print XPU_CFG_PCNOC_CFG_XPU_UMR_CNTL PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   1.           "[ 1 ]      MSACLROE                            = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   0.           "[ 0 ]      MSACLRWE                            = " "0x00 (?),0x01 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0002E0F0$ PER_TESLA9X45_Part5.per -queue XPU_CFG_PCNOC_CFG_XPU_UMR_CNTL"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0002E074
tree " XPU_CFG_PCNOC_CFG_XPU_IDR0 [R]                                    0x0002E074"
  group.long 0x0--0x3
   textline "POR 0x130C2C03    MASK = 0xFF3FBFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print XPU_CFG_PCNOC_CFG_XPU_IDR0 PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   31.          "[ 31 ]     CLIENTREQ_HALT_ACK_HW_EN            = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   30.          "[ 30 ]     SAVERESTORE_HW_EN                   = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   24.--29.     "[29 : 24]  MSB                                 = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?),0x08 (?),0x09 (?),0x0A (?),0x0B (?),0x0C (?),0x0D (?),0x0E (?),0x0F (?),0x10 (?),0x11 (?),0x12 (?),0x13 (?),0x14 (?),0x15 (?),0x16 (?),0x17 (?),0x18 (?),0x19 (?),0x1A (?),0x1B (?),0x1C (?),0x1D (?),0x1E (?),0x1F (?),0x20 (?),0x21 (?),0x22 (?),0x23 (?),0x24 (?),0x25 (?),0x26 (?),0x27 (?),0x28 (?),0x29 (?),0x2A (?),0x2B (?),0x2C (?),0x2D (?),0x2E (?),0x2F (?),0x30 (?),0x31 (?),0x32 (?),0x33 (?),0x34 (?),0x35 (?),0x36 (?),0x37 (?),0x38 (?),0x39 (?),0x3A (?),0x3B (?),0x3C (?),0x3D (?),0x3E (?),0x3F (?)"
   textline ""
   bitfld.long 0x0   16.--21.     "[21 : 16]  LSB                                 = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?),0x08 (?),0x09 (?),0x0A (?),0x0B (?),0x0C (?),0x0D (?),0x0E (?),0x0F (?),0x10 (?),0x11 (?),0x12 (?),0x13 (?),0x14 (?),0x15 (?),0x16 (?),0x17 (?),0x18 (?),0x19 (?),0x1A (?),0x1B (?),0x1C (?),0x1D (?),0x1E (?),0x1F (?),0x20 (?),0x21 (?),0x22 (?),0x23 (?),0x24 (?),0x25 (?),0x26 (?),0x27 (?),0x28 (?),0x29 (?),0x2A (?),0x2B (?),0x2C (?),0x2D (?),0x2E (?),0x2F (?),0x30 (?),0x31 (?),0x32 (?),0x33 (?),0x34 (?),0x35 (?),0x36 (?),0x37 (?),0x38 (?),0x39 (?),0x3A (?),0x3B (?),0x3C (?),0x3D (?),0x3E (?),0x3F (?)"
   textline ""
   bitfld.long 0x0   15.          "[ 15 ]     BLED                                = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   12.--13.     "[13 : 12]  XPUT                                = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?)"
   textline ""
   bitfld.long 0x0   11.          "[ 11 ]     PT                                  = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   10.          "[ 10 ]     MV                                  = " "0x00 (?),0x01 (?)"
   textline ""
   hexmask.long.word 0 0.--9. 1   "[9 : 0]    NRG                                 = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0002E074$ PER_TESLA9X45_Part5.per -queue XPU_CFG_PCNOC_CFG_XPU_IDR0"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0002E078
tree " XPU_CFG_PCNOC_CFG_XPU_IDR1 [R]                                    0x0002E078"
  group.long 0x0--0x3
   textline "POR 0x1F090A1F    MASK = 0x7F3FFEFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print XPU_CFG_PCNOC_CFG_XPU_IDR1 PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   30.          "[ 30 ]     AMT_HW_ENABLE                       = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   24.--29.     "[29 : 24]  CLIENT_ADDR_WIDTH                   = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?),0x08 (?),0x09 (?),0x0A (?),0x0B (?),0x0C (?),0x0D (?),0x0E (?),0x0F (?),0x10 (?),0x11 (?),0x12 (?),0x13 (?),0x14 (?),0x15 (?),0x16 (?),0x17 (?),0x18 (?),0x19 (?),0x1A (?),0x1B (?),0x1C (?),0x1D (?),0x1E (?),0x1F (?),0x20 (?),0x21 (?),0x22 (?),0x23 (?),0x24 (?),0x25 (?),0x26 (?),0x27 (?),0x28 (?),0x29 (?),0x2A (?),0x2B (?),0x2C (?),0x2D (?),0x2E (?),0x2F (?),0x30 (?),0x31 (?),0x32 (?),0x33 (?),0x34 (?),0x35 (?),0x36 (?),0x37 (?),0x38 (?),0x39 (?),0x3A (?),0x3B (?),0x3C (?),0x3D (?),0x3E (?),0x3F (?)"
   textline ""
   bitfld.long 0x0   16.--21.     "[21 : 16]  CONFIG_ADDR_WIDTH                   = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?),0x08 (?),0x09 (?),0x0A (?),0x0B (?),0x0C (?),0x0D (?),0x0E (?),0x0F (?),0x10 (?),0x11 (?),0x12 (?),0x13 (?),0x14 (?),0x15 (?),0x16 (?),0x17 (?),0x18 (?),0x19 (?),0x1A (?),0x1B (?),0x1C (?),0x1D (?),0x1E (?),0x1F (?),0x20 (?),0x21 (?),0x22 (?),0x23 (?),0x24 (?),0x25 (?),0x26 (?),0x27 (?),0x28 (?),0x29 (?),0x2A (?),0x2B (?),0x2C (?),0x2D (?),0x2E (?),0x2F (?),0x30 (?),0x31 (?),0x32 (?),0x33 (?),0x34 (?),0x35 (?),0x36 (?),0x37 (?),0x38 (?),0x39 (?),0x3A (?),0x3B (?),0x3C (?),0x3D (?),0x3E (?),0x3F (?)"
   textline ""
   bitfld.long 0x0   15.          "[ 15 ]     QRIB_EN                             = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   14.          "[ 14 ]     ASYNC_MODE                          = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   13.          "[ 13 ]     CONFIG_TYPE                         = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   12.          "[ 12 ]     CLIENT_PIPELINE_ENABLED             = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   11.          "[ 11 ]     MSA_CHECK_HW_ENABLE                 = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   10.          "[ 10 ]     XPU_SYND_REG_ABSENT                 = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   9.           "[ 9 ]      TZXPU                               = " "0x00 (?),0x01 (?)"
   textline ""
   hexmask.long.byte 0 0.--7. 1   "[7 : 0]    NVMID                               = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0002E078$ PER_TESLA9X45_Part5.per -queue XPU_CFG_PCNOC_CFG_XPU_IDR1"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0002E07C
tree " XPU_CFG_PCNOC_CFG_XPU_REV [R]                                     0x0002E07C"
  group.long 0x0--0x3
   textline "POR 0x20060000    MASK = 0xFFFFFFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print XPU_CFG_PCNOC_CFG_XPU_REV PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   28.--31.     "[31 : 28]  MAJOR                               = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?),0x08 (?),0x09 (?),0x0A (?),0x0B (?),0x0C (?),0x0D (?),0x0E (?),0x0F (?)"
   textline ""
   hexmask.long.word 0 16.--27. 1 "[27 : 16]  MINOR                               = "
   textline ""
   hexmask.long.word 0 0.--15. 1  "[15 : 0]   STEP                                = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0002E07C$ PER_TESLA9X45_Part5.per -queue XPU_CFG_PCNOC_CFG_XPU_REV"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0002E200
tree " XPU_CFG_PCNOC_CFG_XPU_PRT0_RACR0 [RW] (n,m)[(0:0),(0:3)]          0x0002E200"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0xFFFFFFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print XPU_CFG_PCNOC_CFG_XPU_PRT0_RACR0 PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.long 0 0.--31. 1  "[31 : 0]   RE                                  = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0002E200$ PER_TESLA9X45_Part5.per -queue XPU_CFG_PCNOC_CFG_XPU_PRT0_RACR0"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0002E204
tree " XPU_CFG_PCNOC_CFG_XPU_PRT0_RACR1 [RW] (n,m)[(0:0),(0:3)]          0x0002E204"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0xFFFFFFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print XPU_CFG_PCNOC_CFG_XPU_PRT0_RACR1 PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.long 0 0.--31. 1  "[31 : 0]   RE                                  = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0002E204$ PER_TESLA9X45_Part5.per -queue XPU_CFG_PCNOC_CFG_XPU_PRT0_RACR1"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0002E208
tree " XPU_CFG_PCNOC_CFG_XPU_PRT0_RACR2 [RW] (n,m)[(0:0),(0:3)]          0x0002E208"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0xFFFFFFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print XPU_CFG_PCNOC_CFG_XPU_PRT0_RACR2 PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.long 0 0.--31. 1  "[31 : 0]   RE                                  = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0002E208$ PER_TESLA9X45_Part5.per -queue XPU_CFG_PCNOC_CFG_XPU_PRT0_RACR2"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0002E20C
tree " XPU_CFG_PCNOC_CFG_XPU_PRT0_RACR3 [RW] (n,m)[(0:0),(0:3)]          0x0002E20C"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0xFFFFFFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print XPU_CFG_PCNOC_CFG_XPU_PRT0_RACR3 PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.long 0 0.--31. 1  "[31 : 0]   RE                                  = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0002E20C$ PER_TESLA9X45_Part5.per -queue XPU_CFG_PCNOC_CFG_XPU_PRT0_RACR3"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0002E220
tree " XPU_CFG_PCNOC_CFG_XPU_PRT0_WACR0 [RW] (n,m)[(0:0),(0:3)]          0x0002E220"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0xFFFFFFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print XPU_CFG_PCNOC_CFG_XPU_PRT0_WACR0 PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.long 0 0.--31. 1  "[31 : 0]   WE                                  = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0002E220$ PER_TESLA9X45_Part5.per -queue XPU_CFG_PCNOC_CFG_XPU_PRT0_WACR0"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0002E224
tree " XPU_CFG_PCNOC_CFG_XPU_PRT0_WACR1 [RW] (n,m)[(0:0),(0:3)]          0x0002E224"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0xFFFFFFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print XPU_CFG_PCNOC_CFG_XPU_PRT0_WACR1 PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.long 0 0.--31. 1  "[31 : 0]   WE                                  = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0002E224$ PER_TESLA9X45_Part5.per -queue XPU_CFG_PCNOC_CFG_XPU_PRT0_WACR1"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0002E228
tree " XPU_CFG_PCNOC_CFG_XPU_PRT0_WACR2 [RW] (n,m)[(0:0),(0:3)]          0x0002E228"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0xFFFFFFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print XPU_CFG_PCNOC_CFG_XPU_PRT0_WACR2 PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.long 0 0.--31. 1  "[31 : 0]   WE                                  = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0002E228$ PER_TESLA9X45_Part5.per -queue XPU_CFG_PCNOC_CFG_XPU_PRT0_WACR2"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0002E22C
tree " XPU_CFG_PCNOC_CFG_XPU_PRT0_WACR3 [RW] (n,m)[(0:0),(0:3)]          0x0002E22C"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0xFFFFFFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print XPU_CFG_PCNOC_CFG_XPU_PRT0_WACR3 PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.long 0 0.--31. 1  "[31 : 0]   WE                                  = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0002E22C$ PER_TESLA9X45_Part5.per -queue XPU_CFG_PCNOC_CFG_XPU_PRT0_WACR3"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0002E240
tree " XPU_CFG_PCNOC_CFG_XPU_PRT0_START0 [RW] n[3:0]                     0x0002E240"
  group.long 0x0--0x3
   textline "POR 0x000FF000    MASK = 0x000FF000    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print XPU_CFG_PCNOC_CFG_XPU_PRT0_START0 PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.byte 0 12.--19. 1 "[19 : 12]  ADDR                                = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0002E240$ PER_TESLA9X45_Part5.per -queue XPU_CFG_PCNOC_CFG_XPU_PRT0_START0"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0002E2C0
tree " XPU_CFG_PCNOC_CFG_XPU_PRT1_START0 [RW] n[3:0]                     0x0002E2C0"
  group.long 0x0--0x3
   textline "POR 0x000FF000    MASK = 0x000FF000    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print XPU_CFG_PCNOC_CFG_XPU_PRT1_START0 PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.byte 0 12.--19. 1 "[19 : 12]  ADDR                                = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0002E2C0$ PER_TESLA9X45_Part5.per -queue XPU_CFG_PCNOC_CFG_XPU_PRT1_START0"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0002E340
tree " XPU_CFG_PCNOC_CFG_XPU_PRT2_START0 [RW] n[3:0]                     0x0002E340"
  group.long 0x0--0x3
   textline "POR 0x000FF000    MASK = 0x000FF000    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print XPU_CFG_PCNOC_CFG_XPU_PRT2_START0 PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.byte 0 12.--19. 1 "[19 : 12]  ADDR                                = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0002E340$ PER_TESLA9X45_Part5.per -queue XPU_CFG_PCNOC_CFG_XPU_PRT2_START0"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0002E3C0
tree " XPU_CFG_PCNOC_CFG_XPU_PRT3_START0 [RW] n[3:0]                     0x0002E3C0"
  group.long 0x0--0x3
   textline "POR 0x000FF000    MASK = 0x000FF000    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print XPU_CFG_PCNOC_CFG_XPU_PRT3_START0 PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.byte 0 12.--19. 1 "[19 : 12]  ADDR                                = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0002E3C0$ PER_TESLA9X45_Part5.per -queue XPU_CFG_PCNOC_CFG_XPU_PRT3_START0"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0002E248
tree " XPU_CFG_PCNOC_CFG_XPU_PRT0_END0 [RW] n[3:0]                       0x0002E248"
  group.long 0x0--0x3
   textline "POR 0x000FF000    MASK = 0x000FF000    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print XPU_CFG_PCNOC_CFG_XPU_PRT0_END0 PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.byte 0 12.--19. 1 "[19 : 12]  ADDR                                = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0002E248$ PER_TESLA9X45_Part5.per -queue XPU_CFG_PCNOC_CFG_XPU_PRT0_END0"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0002E2C8
tree " XPU_CFG_PCNOC_CFG_XPU_PRT1_END0 [RW] n[3:0]                       0x0002E2C8"
  group.long 0x0--0x3
   textline "POR 0x000FF000    MASK = 0x000FF000    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print XPU_CFG_PCNOC_CFG_XPU_PRT1_END0 PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.byte 0 12.--19. 1 "[19 : 12]  ADDR                                = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0002E2C8$ PER_TESLA9X45_Part5.per -queue XPU_CFG_PCNOC_CFG_XPU_PRT1_END0"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0002E348
tree " XPU_CFG_PCNOC_CFG_XPU_PRT2_END0 [RW] n[3:0]                       0x0002E348"
  group.long 0x0--0x3
   textline "POR 0x000FF000    MASK = 0x000FF000    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print XPU_CFG_PCNOC_CFG_XPU_PRT2_END0 PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.byte 0 12.--19. 1 "[19 : 12]  ADDR                                = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0002E348$ PER_TESLA9X45_Part5.per -queue XPU_CFG_PCNOC_CFG_XPU_PRT2_END0"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0002E3C8
tree " XPU_CFG_PCNOC_CFG_XPU_PRT3_END0 [RW] n[3:0]                       0x0002E3C8"
  group.long 0x0--0x3
   textline "POR 0x000FF000    MASK = 0x000FF000    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print XPU_CFG_PCNOC_CFG_XPU_PRT3_END0 PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.byte 0 12.--19. 1 "[19 : 12]  ADDR                                = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0002E3C8$ PER_TESLA9X45_Part5.per -queue XPU_CFG_PCNOC_CFG_XPU_PRT3_END0"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0002E250
tree " XPU_CFG_PCNOC_CFG_XPU_PRT0_SCR [RW] n[3:0]                        0x0002E250"
  group.long 0x0--0x3
   textline "POR 0x00000001    MASK = 0x0000003F    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print XPU_CFG_PCNOC_CFG_XPU_PRT0_SCR PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   5.           "[ 5 ]      SCLROE                              = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   4.           "[ 4 ]      VMIDCLROE                           = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   3.           "[ 3 ]      MSACLROE                            = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   2.           "[ 2 ]      VMIDCLRWE                           = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   1.           "[ 1 ]      MSACLRWE                            = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   0.           "[ 0 ]      NS                                  = " "0x00 (?),0x01 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0002E250$ PER_TESLA9X45_Part5.per -queue XPU_CFG_PCNOC_CFG_XPU_PRT0_SCR"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0002E2D0
tree " XPU_CFG_PCNOC_CFG_XPU_PRT1_SCR [RW] n[3:0]                        0x0002E2D0"
  group.long 0x0--0x3
   textline "POR 0x00000001    MASK = 0x0000003F    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print XPU_CFG_PCNOC_CFG_XPU_PRT1_SCR PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   5.           "[ 5 ]      SCLROE                              = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   4.           "[ 4 ]      VMIDCLROE                           = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   3.           "[ 3 ]      MSACLROE                            = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   2.           "[ 2 ]      VMIDCLRWE                           = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   1.           "[ 1 ]      MSACLRWE                            = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   0.           "[ 0 ]      NS                                  = " "0x00 (?),0x01 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0002E2D0$ PER_TESLA9X45_Part5.per -queue XPU_CFG_PCNOC_CFG_XPU_PRT1_SCR"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0002E350
tree " XPU_CFG_PCNOC_CFG_XPU_PRT2_SCR [RW] n[3:0]                        0x0002E350"
  group.long 0x0--0x3
   textline "POR 0x00000001    MASK = 0x0000003F    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print XPU_CFG_PCNOC_CFG_XPU_PRT2_SCR PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   5.           "[ 5 ]      SCLROE                              = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   4.           "[ 4 ]      VMIDCLROE                           = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   3.           "[ 3 ]      MSACLROE                            = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   2.           "[ 2 ]      VMIDCLRWE                           = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   1.           "[ 1 ]      MSACLRWE                            = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   0.           "[ 0 ]      NS                                  = " "0x00 (?),0x01 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0002E350$ PER_TESLA9X45_Part5.per -queue XPU_CFG_PCNOC_CFG_XPU_PRT2_SCR"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0002E3D0
tree " XPU_CFG_PCNOC_CFG_XPU_PRT3_SCR [RW] n[3:0]                        0x0002E3D0"
  group.long 0x0--0x3
   textline "POR 0x00000001    MASK = 0x0000003F    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print XPU_CFG_PCNOC_CFG_XPU_PRT3_SCR PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   5.           "[ 5 ]      SCLROE                              = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   4.           "[ 4 ]      VMIDCLROE                           = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   3.           "[ 3 ]      MSACLROE                            = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   2.           "[ 2 ]      VMIDCLRWE                           = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   1.           "[ 1 ]      MSACLRWE                            = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   0.           "[ 0 ]      NS                                  = " "0x00 (?),0x01 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0002E3D0$ PER_TESLA9X45_Part5.per -queue XPU_CFG_PCNOC_CFG_XPU_PRT3_SCR"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0002E254
tree " XPU_CFG_PCNOC_CFG_XPU_PRT0_MCR [RW] n[3:0]                        0x0002E254"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x0000003F    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print XPU_CFG_PCNOC_CFG_XPU_PRT0_MCR PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   5.           "[ 5 ]      MSACLROE                            = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   4.           "[ 4 ]      VMIDCLROE                           = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   3.           "[ 3 ]      SCLROE                              = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   2.           "[ 2 ]      VMIDCLE                             = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   1.           "[ 1 ]      SCLE                                = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   0.           "[ 0 ]      MSAE                                = " "0x00 (?),0x01 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0002E254$ PER_TESLA9X45_Part5.per -queue XPU_CFG_PCNOC_CFG_XPU_PRT0_MCR"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0002E2D4
tree " XPU_CFG_PCNOC_CFG_XPU_PRT1_MCR [RW] n[3:0]                        0x0002E2D4"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x0000003F    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print XPU_CFG_PCNOC_CFG_XPU_PRT1_MCR PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   5.           "[ 5 ]      MSACLROE                            = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   4.           "[ 4 ]      VMIDCLROE                           = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   3.           "[ 3 ]      SCLROE                              = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   2.           "[ 2 ]      VMIDCLE                             = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   1.           "[ 1 ]      SCLE                                = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   0.           "[ 0 ]      MSAE                                = " "0x00 (?),0x01 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0002E2D4$ PER_TESLA9X45_Part5.per -queue XPU_CFG_PCNOC_CFG_XPU_PRT1_MCR"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0002E354
tree " XPU_CFG_PCNOC_CFG_XPU_PRT2_MCR [RW] n[3:0]                        0x0002E354"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x0000003F    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print XPU_CFG_PCNOC_CFG_XPU_PRT2_MCR PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   5.           "[ 5 ]      MSACLROE                            = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   4.           "[ 4 ]      VMIDCLROE                           = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   3.           "[ 3 ]      SCLROE                              = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   2.           "[ 2 ]      VMIDCLE                             = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   1.           "[ 1 ]      SCLE                                = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   0.           "[ 0 ]      MSAE                                = " "0x00 (?),0x01 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0002E354$ PER_TESLA9X45_Part5.per -queue XPU_CFG_PCNOC_CFG_XPU_PRT2_MCR"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0002E3D4
tree " XPU_CFG_PCNOC_CFG_XPU_PRT3_MCR [RW] n[3:0]                        0x0002E3D4"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x0000003F    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print XPU_CFG_PCNOC_CFG_XPU_PRT3_MCR PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   5.           "[ 5 ]      MSACLROE                            = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   4.           "[ 4 ]      VMIDCLROE                           = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   3.           "[ 3 ]      SCLROE                              = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   2.           "[ 2 ]      VMIDCLE                             = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   1.           "[ 1 ]      SCLE                                = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   0.           "[ 0 ]      MSAE                                = " "0x00 (?),0x01 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0002E3D4$ PER_TESLA9X45_Part5.per -queue XPU_CFG_PCNOC_CFG_XPU_PRT3_MCR"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0002E258
tree " XPU_CFG_PCNOC_CFG_XPU_PRT0_CNTL0 [RW] n[3:0]                      0x0002E258"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x80000000    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print XPU_CFG_PCNOC_CFG_XPU_PRT0_CNTL0 PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   31.          "[ 31 ]     PD                                  = " "0x00 (?),0x01 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0002E258$ PER_TESLA9X45_Part5.per -queue XPU_CFG_PCNOC_CFG_XPU_PRT0_CNTL0"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0002E2D8
tree " XPU_CFG_PCNOC_CFG_XPU_PRT1_CNTL0 [RW] n[3:0]                      0x0002E2D8"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x80000000    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print XPU_CFG_PCNOC_CFG_XPU_PRT1_CNTL0 PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   31.          "[ 31 ]     PD                                  = " "0x00 (?),0x01 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0002E2D8$ PER_TESLA9X45_Part5.per -queue XPU_CFG_PCNOC_CFG_XPU_PRT1_CNTL0"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0002E358
tree " XPU_CFG_PCNOC_CFG_XPU_PRT2_CNTL0 [RW] n[3:0]                      0x0002E358"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x80000000    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print XPU_CFG_PCNOC_CFG_XPU_PRT2_CNTL0 PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   31.          "[ 31 ]     PD                                  = " "0x00 (?),0x01 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0002E358$ PER_TESLA9X45_Part5.per -queue XPU_CFG_PCNOC_CFG_XPU_PRT2_CNTL0"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0002E3D8
tree " XPU_CFG_PCNOC_CFG_XPU_PRT3_CNTL0 [RW] n[3:0]                      0x0002E3D8"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x80000000    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print XPU_CFG_PCNOC_CFG_XPU_PRT3_CNTL0 PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   31.          "[ 31 ]     PD                                  = " "0x00 (?),0x01 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0002E3D8$ PER_TESLA9X45_Part5.per -queue XPU_CFG_PCNOC_CFG_XPU_PRT3_CNTL0"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0002E25C
tree " XPU_CFG_PCNOC_CFG_XPU_PRT0_CNTL1 [W] n[3:0]                       0x0002E25C"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x00000003    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print XPU_CFG_PCNOC_CFG_XPU_PRT0_CNTL1 PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   1.           "[ 1 ]      ASRC                                = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   0.           "[ 0 ]      CSRC                                = " "0x00 (?),0x01 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0002E25C$ PER_TESLA9X45_Part5.per -queue XPU_CFG_PCNOC_CFG_XPU_PRT0_CNTL1"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0002E2DC
tree " XPU_CFG_PCNOC_CFG_XPU_PRT1_CNTL1 [W] n[3:0]                       0x0002E2DC"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x00000003    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print XPU_CFG_PCNOC_CFG_XPU_PRT1_CNTL1 PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   1.           "[ 1 ]      ASRC                                = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   0.           "[ 0 ]      CSRC                                = " "0x00 (?),0x01 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0002E2DC$ PER_TESLA9X45_Part5.per -queue XPU_CFG_PCNOC_CFG_XPU_PRT1_CNTL1"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0002E35C
tree " XPU_CFG_PCNOC_CFG_XPU_PRT2_CNTL1 [W] n[3:0]                       0x0002E35C"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x00000003    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print XPU_CFG_PCNOC_CFG_XPU_PRT2_CNTL1 PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   1.           "[ 1 ]      ASRC                                = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   0.           "[ 0 ]      CSRC                                = " "0x00 (?),0x01 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0002E35C$ PER_TESLA9X45_Part5.per -queue XPU_CFG_PCNOC_CFG_XPU_PRT2_CNTL1"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0002E3DC
tree " XPU_CFG_PCNOC_CFG_XPU_PRT3_CNTL1 [W] n[3:0]                       0x0002E3DC"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x00000003    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print XPU_CFG_PCNOC_CFG_XPU_PRT3_CNTL1 PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   1.           "[ 1 ]      ASRC                                = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   0.           "[ 0 ]      CSRC                                = " "0x00 (?),0x01 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0002E3DC$ PER_TESLA9X45_Part5.per -queue XPU_CFG_PCNOC_CFG_XPU_PRT3_CNTL1"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0002D000
tree " XPU_CFG_SNOC_CFG_XPU_SCR [RW]                                     0x0002D000"
  group.long 0x0--0x3
   textline "POR 0x00000106    MASK = 0x0000077F    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print XPU_CFG_SNOC_CFG_XPU_SCR PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   10.          "[ 10 ]     SCLEIE                              = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   9.           "[ 9 ]      SCFGEIE                             = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   8.           "[ 8 ]      DYNAMIC_CLK_EN                      = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   6.           "[ 6 ]      NSRGCLEE                            = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   5.           "[ 5 ]      NSCFGE                              = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   4.           "[ 4 ]      SDCDEE                              = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   3.           "[ 3 ]      SEIE                                = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   2.           "[ 2 ]      SCLERE                              = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   1.           "[ 1 ]      SCFGERE                             = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   0.           "[ 0 ]      XPUNSE                              = " "0x00 (?),0x01 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0002D000$ PER_TESLA9X45_Part5.per -queue XPU_CFG_SNOC_CFG_XPU_SCR"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0002D004
tree " XPU_CFG_SNOC_CFG_XPU_SWDR [RW]                                    0x0002D004"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x00000001    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print XPU_CFG_SNOC_CFG_XPU_SWDR PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   0.           "[ 0 ]      SCFGWD                              = " "0x00 (?),0x01 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0002D004$ PER_TESLA9X45_Part5.per -queue XPU_CFG_SNOC_CFG_XPU_SWDR"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0002D008
tree " XPU_CFG_SNOC_CFG_XPU_PRTN_RACR_SSHADOW [RW]                       0x0002D008"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0xFFFFFFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print XPU_CFG_SNOC_CFG_XPU_PRTN_RACR_SSHADOW PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.long 0 0.--31. 1  "[31 : 0]   RE                                  = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0002D008$ PER_TESLA9X45_Part5.per -queue XPU_CFG_SNOC_CFG_XPU_PRTN_RACR_SSHADOW"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0002D00C
tree " XPU_CFG_SNOC_CFG_XPU_PRTN_WACR_SSHADOW [RW]                       0x0002D00C"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0xFFFFFFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print XPU_CFG_SNOC_CFG_XPU_PRTN_WACR_SSHADOW PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.long 0 0.--31. 1  "[31 : 0]   WE                                  = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0002D00C$ PER_TESLA9X45_Part5.per -queue XPU_CFG_SNOC_CFG_XPU_PRTN_WACR_SSHADOW"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0002D010
tree " XPU_CFG_SNOC_CFG_XPU_PRTN_START_SSHADOW0 [RW]                     0x0002D010"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x000FF000    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print XPU_CFG_SNOC_CFG_XPU_PRTN_START_SSHADOW0 PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.byte 0 12.--19. 1 "[19 : 12]  ADDR                                = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0002D010$ PER_TESLA9X45_Part5.per -queue XPU_CFG_SNOC_CFG_XPU_PRTN_START_SSHADOW0"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0002D018
tree " XPU_CFG_SNOC_CFG_XPU_PRTN_END_SSHADOW0 [RW]                       0x0002D018"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x000FF000    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print XPU_CFG_SNOC_CFG_XPU_PRTN_END_SSHADOW0 PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.byte 0 12.--19. 1 "[19 : 12]  ADDR                                = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0002D018$ PER_TESLA9X45_Part5.per -queue XPU_CFG_SNOC_CFG_XPU_PRTN_END_SSHADOW0"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0002D040
tree " XPU_CFG_SNOC_CFG_XPU_SEAR0 [R]                                    0x0002D040"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0xFFFFFFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print XPU_CFG_SNOC_CFG_XPU_SEAR0 PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.long 0 0.--31. 1  "[31 : 0]   PA                                  = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0002D040$ PER_TESLA9X45_Part5.per -queue XPU_CFG_SNOC_CFG_XPU_SEAR0"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0002D048
tree " XPU_CFG_SNOC_CFG_XPU_SESR [RW]                                    0x0002D048"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x8000000F    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print XPU_CFG_SNOC_CFG_XPU_SESR PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   31.          "[ 31 ]     MULTI                               = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   3.           "[ 3 ]      CLMULTI                             = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   2.           "[ 2 ]      CFGMULTI                            = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   1.           "[ 1 ]      CLIENT                              = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   0.           "[ 0 ]      CFG                                 = " "0x00 (?),0x01 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0002D048$ PER_TESLA9X45_Part5.per -queue XPU_CFG_SNOC_CFG_XPU_SESR"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0002D04C
tree " XPU_CFG_SNOC_CFG_XPU_SESRRESTORE [RW]                             0x0002D04C"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x8000000F    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print XPU_CFG_SNOC_CFG_XPU_SESRRESTORE PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   31.          "[ 31 ]     MULTI                               = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   3.           "[ 3 ]      CLMULTI                             = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   2.           "[ 2 ]      CFGMULTI                            = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   1.           "[ 1 ]      CLIENT                              = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   0.           "[ 0 ]      CFG                                 = " "0x00 (?),0x01 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0002D04C$ PER_TESLA9X45_Part5.per -queue XPU_CFG_SNOC_CFG_XPU_SESRRESTORE"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0002D050
tree " XPU_CFG_SNOC_CFG_XPU_SESYNR0 [R]                                  0x0002D050"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0xFFFFFFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print XPU_CFG_SNOC_CFG_XPU_SESYNR0 PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.byte 0 24.--31. 1 "[31 : 24]  ATID                                = "
   textline ""
   hexmask.long.byte 0 16.--23. 1 "[23 : 16]  AVMID                               = "
   textline ""
   bitfld.long 0x0   13.--15.     "[15 : 13]  ABID                                = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?)"
   textline ""
   bitfld.long 0x0   8.--12.      "[12 : 8]   APID                                = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?),0x08 (?),0x09 (?),0x0A (?),0x0B (?),0x0C (?),0x0D (?),0x0E (?),0x0F (?),0x10 (?),0x11 (?),0x12 (?),0x13 (?),0x14 (?),0x15 (?),0x16 (?),0x17 (?),0x18 (?),0x19 (?),0x1A (?),0x1B (?),0x1C (?),0x1D (?),0x1E (?),0x1F (?)"
   textline ""
   hexmask.long.byte 0 0.--7. 1   "[7 : 0]    AMID                                = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0002D050$ PER_TESLA9X45_Part5.per -queue XPU_CFG_SNOC_CFG_XPU_SESYNR0"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0002D054
tree " XPU_CFG_SNOC_CFG_XPU_SESYNR1 [R]                                  0x0002D054"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0xFFFFFFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print XPU_CFG_SNOC_CFG_XPU_SESYNR1 PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   31.          "[ 31 ]     DCD                                 = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   30.          "[ 30 ]     AC                                  = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   29.          "[ 29 ]     BURSTLEN                            = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   28.          "[ 28 ]     ARDALLOCATE                         = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   27.          "[ 27 ]     ABURST                              = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   26.          "[ 26 ]     AEXCLUSIVE                          = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   25.          "[ 25 ]     AWRITE                              = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   24.          "[ 24 ]     AFULL                               = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   23.          "[ 23 ]     ARDBEADNDXEN                        = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   22.          "[ 22 ]     AOOO                                = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   19.--21.     "[21 : 19]  APREQPRIORITY                       = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?)"
   textline ""
   bitfld.long 0x0   16.--18.     "[18 : 16]  ASIZE                               = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?)"
   textline ""
   bitfld.long 0x0   15.          "[ 15 ]     AMSSSELFAUTH                        = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   8.--14.      "[14 : 8]   ALEN                                = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?),0x08 (?),0x09 (?),0x0A (?),0x0B (?),0x0C (?),0x0D (?),0x0E (?),0x0F (?),0x10 (?),0x11 (?),0x12 (?),0x13 (?),0x14 (?),0x15 (?),0x16 (?),0x17 (?),0x18 (?),0x19 (?),0x1A (?),0x1B (?),0x1C (?),0x1D (?),0x1E (?),0x1F (?),0x20 (?),0x21 (?),0x22 (?),0x23 (?),0x24 (?),0x25 (?),0x26 (?),0x27 (?),0x28 (?),0x29 (?),0x2A (?),0x2B (?),0x2C (?),0x2D (?),0x2E (?),0x2F (?),0x30 (?),0x31 (?),0x32 (?),0x33 (?),0x34 (?),0x35 (?),0x36 (?),0x37 (?),0x38 (?),0x39 (?),0x3A (?),0x3B (?),0x3C (?),0x3D (?),0x3E (?),0x3F (?),0x40 (?),0x41 (?),0x42 (?),0x43 (?),0x44 (?),0x45 (?),0x46 (?),0x47 (?),0x48 (?),0x49 (?),0x4A (?),0x4B (?),0x4C (?),0x4D (?),0x4E (?),0x4F (?),0x50 (?),0x51 (?),0x52 (?),0x53 (?),0x54 (?),0x55 (?),0x56 (?),0x57 (?),0x58 (?),0x59 (?),0x5A (?),0x5B (?),0x5C (?),0x5D (?),0x5E (?),0x5F (?),0x60 (?),0x61 (?),0x62 (?),0x63 (?),0x64 (?),0x65 (?),0x66 (?),0x67 (?),0x68 (?),0x69 (?),0x6A (?),0x6B (?),0x6C (?),0x6D (?),0x6E (?),0x6F (?),0x70 (?),0x71 (?),0x72 (?),0x73 (?),0x74 (?),0x75 (?),0x76 (?),0x77 (?),0x78 (?),0x79 (?),0x7A (?),0x7B (?),0x7C (?),0x7D (?),0x7E (?),0x7F (?)"
   textline ""
   bitfld.long 0x0   7.           "[ 7 ]      AINST                               = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   6.           "[ 6 ]      APROTNS                             = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   5.           "[ 5 ]      APRIV                               = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   4.           "[ 4 ]      AINNERSHARED                        = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   3.           "[ 3 ]      ASHARED                             = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   0.--2.       "[2 : 0]    AMEMTYPE                            = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0002D054$ PER_TESLA9X45_Part5.per -queue XPU_CFG_SNOC_CFG_XPU_SESYNR1"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0002D058
tree " XPU_CFG_SNOC_CFG_XPU_SESYNR2 [R]                                  0x0002D058"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x00000007    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print XPU_CFG_SNOC_CFG_XPU_SESYNR2 PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   2.           "[ 2 ]      MODEM_PRT_HIT                       = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   1.           "[ 1 ]      SECURE_PRT_HIT                      = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   0.           "[ 0 ]      NONSECURE_PRT_HIT                   = " "0x00 (?),0x01 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0002D058$ PER_TESLA9X45_Part5.per -queue XPU_CFG_SNOC_CFG_XPU_SESYNR2"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0002D100
tree " XPU_CFG_SNOC_CFG_XPU_MCR [RW]                                     0x0002D100"
  group.long 0x0--0x3
   textline "POR 0x00000106    MASK = 0x0000071F    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print XPU_CFG_SNOC_CFG_XPU_MCR PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   10.          "[ 10 ]     CLEIE                               = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   9.           "[ 9 ]      CFGEIE                              = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   8.           "[ 8 ]      DYNAMIC_CLK_EN                      = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   4.           "[ 4 ]      DCDEE                               = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   3.           "[ 3 ]      EIE                                 = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   2.           "[ 2 ]      CLERE                               = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   1.           "[ 1 ]      CFGERE                              = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   0.           "[ 0 ]      XPUMSAE                             = " "0x00 (?),0x01 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0002D100$ PER_TESLA9X45_Part5.per -queue XPU_CFG_SNOC_CFG_XPU_MCR"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0002D140
tree " XPU_CFG_SNOC_CFG_XPU_MEAR0 [R]                                    0x0002D140"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0xFFFFFFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print XPU_CFG_SNOC_CFG_XPU_MEAR0 PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.long 0 0.--31. 1  "[31 : 0]   PA                                  = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0002D140$ PER_TESLA9X45_Part5.per -queue XPU_CFG_SNOC_CFG_XPU_MEAR0"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0002D148
tree " XPU_CFG_SNOC_CFG_XPU_MESR [RW]                                    0x0002D148"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x8000000F    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print XPU_CFG_SNOC_CFG_XPU_MESR PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   31.          "[ 31 ]     MULTI                               = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   3.           "[ 3 ]      CLMULTI                             = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   2.           "[ 2 ]      CFGMULTI                            = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   1.           "[ 1 ]      CLIENT                              = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   0.           "[ 0 ]      CFG                                 = " "0x00 (?),0x01 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0002D148$ PER_TESLA9X45_Part5.per -queue XPU_CFG_SNOC_CFG_XPU_MESR"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0002D14C
tree " XPU_CFG_SNOC_CFG_XPU_MESRRESTORE [RW]                             0x0002D14C"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x8000000F    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print XPU_CFG_SNOC_CFG_XPU_MESRRESTORE PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   31.          "[ 31 ]     MULTI                               = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   3.           "[ 3 ]      CLMULTI                             = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   2.           "[ 2 ]      CFGMULTI                            = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   1.           "[ 1 ]      CLIENT                              = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   0.           "[ 0 ]      CFG                                 = " "0x00 (?),0x01 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0002D14C$ PER_TESLA9X45_Part5.per -queue XPU_CFG_SNOC_CFG_XPU_MESRRESTORE"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0002D150
tree " XPU_CFG_SNOC_CFG_XPU_MESYNR0 [R]                                  0x0002D150"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0xFFFFFFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print XPU_CFG_SNOC_CFG_XPU_MESYNR0 PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.byte 0 24.--31. 1 "[31 : 24]  ATID                                = "
   textline ""
   hexmask.long.byte 0 16.--23. 1 "[23 : 16]  AVMID                               = "
   textline ""
   bitfld.long 0x0   13.--15.     "[15 : 13]  ABID                                = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?)"
   textline ""
   bitfld.long 0x0   8.--12.      "[12 : 8]   APID                                = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?),0x08 (?),0x09 (?),0x0A (?),0x0B (?),0x0C (?),0x0D (?),0x0E (?),0x0F (?),0x10 (?),0x11 (?),0x12 (?),0x13 (?),0x14 (?),0x15 (?),0x16 (?),0x17 (?),0x18 (?),0x19 (?),0x1A (?),0x1B (?),0x1C (?),0x1D (?),0x1E (?),0x1F (?)"
   textline ""
   hexmask.long.byte 0 0.--7. 1   "[7 : 0]    AMID                                = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0002D150$ PER_TESLA9X45_Part5.per -queue XPU_CFG_SNOC_CFG_XPU_MESYNR0"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0002D154
tree " XPU_CFG_SNOC_CFG_XPU_MESYNR1 [R]                                  0x0002D154"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0xFFFFFFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print XPU_CFG_SNOC_CFG_XPU_MESYNR1 PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   31.          "[ 31 ]     DCD                                 = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   30.          "[ 30 ]     AC                                  = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   29.          "[ 29 ]     BURSTLEN                            = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   28.          "[ 28 ]     ARDALLOCATE                         = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   27.          "[ 27 ]     ABURST                              = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   26.          "[ 26 ]     AEXCLUSIVE                          = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   25.          "[ 25 ]     AWRITE                              = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   24.          "[ 24 ]     AFULL                               = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   23.          "[ 23 ]     ARDBEADNDXEN                        = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   22.          "[ 22 ]     AOOO                                = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   19.--21.     "[21 : 19]  APREQPRIORITY                       = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?)"
   textline ""
   bitfld.long 0x0   16.--18.     "[18 : 16]  ASIZE                               = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?)"
   textline ""
   bitfld.long 0x0   15.          "[ 15 ]     AMSSSELFAUTH                        = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   8.--14.      "[14 : 8]   ALEN                                = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?),0x08 (?),0x09 (?),0x0A (?),0x0B (?),0x0C (?),0x0D (?),0x0E (?),0x0F (?),0x10 (?),0x11 (?),0x12 (?),0x13 (?),0x14 (?),0x15 (?),0x16 (?),0x17 (?),0x18 (?),0x19 (?),0x1A (?),0x1B (?),0x1C (?),0x1D (?),0x1E (?),0x1F (?),0x20 (?),0x21 (?),0x22 (?),0x23 (?),0x24 (?),0x25 (?),0x26 (?),0x27 (?),0x28 (?),0x29 (?),0x2A (?),0x2B (?),0x2C (?),0x2D (?),0x2E (?),0x2F (?),0x30 (?),0x31 (?),0x32 (?),0x33 (?),0x34 (?),0x35 (?),0x36 (?),0x37 (?),0x38 (?),0x39 (?),0x3A (?),0x3B (?),0x3C (?),0x3D (?),0x3E (?),0x3F (?),0x40 (?),0x41 (?),0x42 (?),0x43 (?),0x44 (?),0x45 (?),0x46 (?),0x47 (?),0x48 (?),0x49 (?),0x4A (?),0x4B (?),0x4C (?),0x4D (?),0x4E (?),0x4F (?),0x50 (?),0x51 (?),0x52 (?),0x53 (?),0x54 (?),0x55 (?),0x56 (?),0x57 (?),0x58 (?),0x59 (?),0x5A (?),0x5B (?),0x5C (?),0x5D (?),0x5E (?),0x5F (?),0x60 (?),0x61 (?),0x62 (?),0x63 (?),0x64 (?),0x65 (?),0x66 (?),0x67 (?),0x68 (?),0x69 (?),0x6A (?),0x6B (?),0x6C (?),0x6D (?),0x6E (?),0x6F (?),0x70 (?),0x71 (?),0x72 (?),0x73 (?),0x74 (?),0x75 (?),0x76 (?),0x77 (?),0x78 (?),0x79 (?),0x7A (?),0x7B (?),0x7C (?),0x7D (?),0x7E (?),0x7F (?)"
   textline ""
   bitfld.long 0x0   7.           "[ 7 ]      AINST                               = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   6.           "[ 6 ]      APROTNS                             = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   5.           "[ 5 ]      APRIV                               = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   4.           "[ 4 ]      AINNERSHARED                        = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   3.           "[ 3 ]      ASHARED                             = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   0.--2.       "[2 : 0]    AMEMTYPE                            = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0002D154$ PER_TESLA9X45_Part5.per -queue XPU_CFG_SNOC_CFG_XPU_MESYNR1"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0002D158
tree " XPU_CFG_SNOC_CFG_XPU_MESYNR2 [R]                                  0x0002D158"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x00000007    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print XPU_CFG_SNOC_CFG_XPU_MESYNR2 PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   2.           "[ 2 ]      MODEM_PRT_HIT                       = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   1.           "[ 1 ]      SECURE_PRT_HIT                      = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   0.           "[ 0 ]      NONSECURE_PRT_HIT                   = " "0x00 (?),0x01 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0002D158$ PER_TESLA9X45_Part5.per -queue XPU_CFG_SNOC_CFG_XPU_MESYNR2"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0002D080
tree " XPU_CFG_SNOC_CFG_XPU_CR [RW]                                      0x0002D080"
  group.long 0x0--0x3
   textline "POR 0x00000106    MASK = 0x0001071F    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print XPU_CFG_SNOC_CFG_XPU_CR PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   16.          "[ 16 ]     MSAE                                = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   10.          "[ 10 ]     CLEIE                               = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   9.           "[ 9 ]      CFGEIE                              = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   8.           "[ 8 ]      DYNAMIC_CLK_EN                      = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   4.           "[ 4 ]      DCDEE                               = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   3.           "[ 3 ]      EIE                                 = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   2.           "[ 2 ]      CLERE                               = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   1.           "[ 1 ]      CFGERE                              = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   0.           "[ 0 ]      XPUVMIDE                            = " "0x00 (?),0x01 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0002D080$ PER_TESLA9X45_Part5.per -queue XPU_CFG_SNOC_CFG_XPU_CR"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0002D088
tree " XPU_CFG_SNOC_CFG_XPU_PRTN_RACR_SHADOW [RW]                        0x0002D088"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0xFFFFFFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print XPU_CFG_SNOC_CFG_XPU_PRTN_RACR_SHADOW PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.long 0 0.--31. 1  "[31 : 0]   RE                                  = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0002D088$ PER_TESLA9X45_Part5.per -queue XPU_CFG_SNOC_CFG_XPU_PRTN_RACR_SHADOW"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0002D08C
tree " XPU_CFG_SNOC_CFG_XPU_PRTN_WACR_SHADOW [RW]                        0x0002D08C"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0xFFFFFFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print XPU_CFG_SNOC_CFG_XPU_PRTN_WACR_SHADOW PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.long 0 0.--31. 1  "[31 : 0]   WE                                  = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0002D08C$ PER_TESLA9X45_Part5.per -queue XPU_CFG_SNOC_CFG_XPU_PRTN_WACR_SHADOW"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0002D090
tree " XPU_CFG_SNOC_CFG_XPU_PRTN_START_SHADOW0 [RW]                      0x0002D090"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x000FF000    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print XPU_CFG_SNOC_CFG_XPU_PRTN_START_SHADOW0 PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.byte 0 12.--19. 1 "[19 : 12]  ADDR                                = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0002D090$ PER_TESLA9X45_Part5.per -queue XPU_CFG_SNOC_CFG_XPU_PRTN_START_SHADOW0"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0002D098
tree " XPU_CFG_SNOC_CFG_XPU_PRTN_END_SHADOW0 [RW]                        0x0002D098"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x000FF000    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print XPU_CFG_SNOC_CFG_XPU_PRTN_END_SHADOW0 PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.byte 0 12.--19. 1 "[19 : 12]  ADDR                                = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0002D098$ PER_TESLA9X45_Part5.per -queue XPU_CFG_SNOC_CFG_XPU_PRTN_END_SHADOW0"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0002D0A0
tree " XPU_CFG_SNOC_CFG_XPU_RPU_ACR0 [RW] n[0:0]                         0x0002D0A0"
  group.long 0x0--0x3
   textline "POR 0xFFFFFFFF    MASK = 0xFFFFFFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print XPU_CFG_SNOC_CFG_XPU_RPU_ACR0 PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.long 0 0.--31. 1  "[31 : 0]   RWE                                 = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0002D0A0$ PER_TESLA9X45_Part5.per -queue XPU_CFG_SNOC_CFG_XPU_RPU_ACR0"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0002D0C0
tree " XPU_CFG_SNOC_CFG_XPU_EAR0 [R]                                     0x0002D0C0"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0xFFFFFFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print XPU_CFG_SNOC_CFG_XPU_EAR0 PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.long 0 0.--31. 1  "[31 : 0]   PA                                  = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0002D0C0$ PER_TESLA9X45_Part5.per -queue XPU_CFG_SNOC_CFG_XPU_EAR0"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0002D0C8
tree " XPU_CFG_SNOC_CFG_XPU_ESR [RW]                                     0x0002D0C8"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x8000000F    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print XPU_CFG_SNOC_CFG_XPU_ESR PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   31.          "[ 31 ]     MULTI                               = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   3.           "[ 3 ]      CLMULTI                             = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   2.           "[ 2 ]      CFGMULTI                            = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   1.           "[ 1 ]      CLIENT                              = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   0.           "[ 0 ]      CFG                                 = " "0x00 (?),0x01 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0002D0C8$ PER_TESLA9X45_Part5.per -queue XPU_CFG_SNOC_CFG_XPU_ESR"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0002D0CC
tree " XPU_CFG_SNOC_CFG_XPU_ESRRESTORE [RW]                              0x0002D0CC"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x8000000F    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print XPU_CFG_SNOC_CFG_XPU_ESRRESTORE PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   31.          "[ 31 ]     MULTI                               = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   3.           "[ 3 ]      CLMULTI                             = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   2.           "[ 2 ]      CFGMULTI                            = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   1.           "[ 1 ]      CLIENT                              = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   0.           "[ 0 ]      CFG                                 = " "0x00 (?),0x01 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0002D0CC$ PER_TESLA9X45_Part5.per -queue XPU_CFG_SNOC_CFG_XPU_ESRRESTORE"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0002D0D0
tree " XPU_CFG_SNOC_CFG_XPU_ESYNR0 [R]                                   0x0002D0D0"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0xFFFFFFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print XPU_CFG_SNOC_CFG_XPU_ESYNR0 PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.byte 0 24.--31. 1 "[31 : 24]  ATID                                = "
   textline ""
   hexmask.long.byte 0 16.--23. 1 "[23 : 16]  AVMID                               = "
   textline ""
   bitfld.long 0x0   13.--15.     "[15 : 13]  ABID                                = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?)"
   textline ""
   bitfld.long 0x0   8.--12.      "[12 : 8]   APID                                = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?),0x08 (?),0x09 (?),0x0A (?),0x0B (?),0x0C (?),0x0D (?),0x0E (?),0x0F (?),0x10 (?),0x11 (?),0x12 (?),0x13 (?),0x14 (?),0x15 (?),0x16 (?),0x17 (?),0x18 (?),0x19 (?),0x1A (?),0x1B (?),0x1C (?),0x1D (?),0x1E (?),0x1F (?)"
   textline ""
   hexmask.long.byte 0 0.--7. 1   "[7 : 0]    AMID                                = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0002D0D0$ PER_TESLA9X45_Part5.per -queue XPU_CFG_SNOC_CFG_XPU_ESYNR0"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0002D0D4
tree " XPU_CFG_SNOC_CFG_XPU_ESYNR1 [R]                                   0x0002D0D4"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0xFFFFFFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print XPU_CFG_SNOC_CFG_XPU_ESYNR1 PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   31.          "[ 31 ]     DCD                                 = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   30.          "[ 30 ]     AC                                  = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   29.          "[ 29 ]     BURSTLEN                            = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   28.          "[ 28 ]     ARDALLOCATE                         = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   27.          "[ 27 ]     ABURST                              = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   26.          "[ 26 ]     AEXCLUSIVE                          = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   25.          "[ 25 ]     AWRITE                              = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   24.          "[ 24 ]     AFULL                               = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   23.          "[ 23 ]     ARDBEADNDXEN                        = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   22.          "[ 22 ]     AOOO                                = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   19.--21.     "[21 : 19]  APREQPRIORITY                       = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?)"
   textline ""
   bitfld.long 0x0   16.--18.     "[18 : 16]  ASIZE                               = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?)"
   textline ""
   bitfld.long 0x0   15.          "[ 15 ]     AMSSSELFAUTH                        = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   8.--14.      "[14 : 8]   ALEN                                = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?),0x08 (?),0x09 (?),0x0A (?),0x0B (?),0x0C (?),0x0D (?),0x0E (?),0x0F (?),0x10 (?),0x11 (?),0x12 (?),0x13 (?),0x14 (?),0x15 (?),0x16 (?),0x17 (?),0x18 (?),0x19 (?),0x1A (?),0x1B (?),0x1C (?),0x1D (?),0x1E (?),0x1F (?),0x20 (?),0x21 (?),0x22 (?),0x23 (?),0x24 (?),0x25 (?),0x26 (?),0x27 (?),0x28 (?),0x29 (?),0x2A (?),0x2B (?),0x2C (?),0x2D (?),0x2E (?),0x2F (?),0x30 (?),0x31 (?),0x32 (?),0x33 (?),0x34 (?),0x35 (?),0x36 (?),0x37 (?),0x38 (?),0x39 (?),0x3A (?),0x3B (?),0x3C (?),0x3D (?),0x3E (?),0x3F (?),0x40 (?),0x41 (?),0x42 (?),0x43 (?),0x44 (?),0x45 (?),0x46 (?),0x47 (?),0x48 (?),0x49 (?),0x4A (?),0x4B (?),0x4C (?),0x4D (?),0x4E (?),0x4F (?),0x50 (?),0x51 (?),0x52 (?),0x53 (?),0x54 (?),0x55 (?),0x56 (?),0x57 (?),0x58 (?),0x59 (?),0x5A (?),0x5B (?),0x5C (?),0x5D (?),0x5E (?),0x5F (?),0x60 (?),0x61 (?),0x62 (?),0x63 (?),0x64 (?),0x65 (?),0x66 (?),0x67 (?),0x68 (?),0x69 (?),0x6A (?),0x6B (?),0x6C (?),0x6D (?),0x6E (?),0x6F (?),0x70 (?),0x71 (?),0x72 (?),0x73 (?),0x74 (?),0x75 (?),0x76 (?),0x77 (?),0x78 (?),0x79 (?),0x7A (?),0x7B (?),0x7C (?),0x7D (?),0x7E (?),0x7F (?)"
   textline ""
   bitfld.long 0x0   7.           "[ 7 ]      AINST                               = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   6.           "[ 6 ]      APROTNS                             = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   5.           "[ 5 ]      APRIV                               = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   4.           "[ 4 ]      AINNERSHARED                        = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   3.           "[ 3 ]      ASHARED                             = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   0.--2.       "[2 : 0]    AMEMTYPE                            = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0002D0D4$ PER_TESLA9X45_Part5.per -queue XPU_CFG_SNOC_CFG_XPU_ESYNR1"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0002D0D8
tree " XPU_CFG_SNOC_CFG_XPU_ESYNR2 [R]                                   0x0002D0D8"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x00000007    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print XPU_CFG_SNOC_CFG_XPU_ESYNR2 PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   2.           "[ 2 ]      MODEM_PRT_HIT                       = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   1.           "[ 1 ]      SECURE_PRT_HIT                      = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   0.           "[ 0 ]      NONSECURE_PRT_HIT                   = " "0x00 (?),0x01 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0002D0D8$ PER_TESLA9X45_Part5.per -queue XPU_CFG_SNOC_CFG_XPU_ESYNR2"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0002D0E0
tree " XPU_CFG_SNOC_CFG_XPU_UMR_RACR [RW]                                0x0002D0E0"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0xFFFFFFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print XPU_CFG_SNOC_CFG_XPU_UMR_RACR PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.long 0 0.--31. 1  "[31 : 0]   RE                                  = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0002D0E0$ PER_TESLA9X45_Part5.per -queue XPU_CFG_SNOC_CFG_XPU_UMR_RACR"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0002D0E4
tree " XPU_CFG_SNOC_CFG_XPU_UMR_WACR [RW]                                0x0002D0E4"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0xFFFFFFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print XPU_CFG_SNOC_CFG_XPU_UMR_WACR PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.long 0 0.--31. 1  "[31 : 0]   WE                                  = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0002D0E4$ PER_TESLA9X45_Part5.per -queue XPU_CFG_SNOC_CFG_XPU_UMR_WACR"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0002D0F0
tree " XPU_CFG_SNOC_CFG_XPU_UMR_CNTL [RW]                                0x0002D0F0"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x00000003    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print XPU_CFG_SNOC_CFG_XPU_UMR_CNTL PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   1.           "[ 1 ]      MSACLROE                            = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   0.           "[ 0 ]      MSACLRWE                            = " "0x00 (?),0x01 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0002D0F0$ PER_TESLA9X45_Part5.per -queue XPU_CFG_SNOC_CFG_XPU_UMR_CNTL"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0002D074
tree " XPU_CFG_SNOC_CFG_XPU_IDR0 [R]                                     0x0002D074"
  group.long 0x0--0x3
   textline "POR 0x130C2C03    MASK = 0xFF3FBFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print XPU_CFG_SNOC_CFG_XPU_IDR0 PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   31.          "[ 31 ]     CLIENTREQ_HALT_ACK_HW_EN            = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   30.          "[ 30 ]     SAVERESTORE_HW_EN                   = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   24.--29.     "[29 : 24]  MSB                                 = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?),0x08 (?),0x09 (?),0x0A (?),0x0B (?),0x0C (?),0x0D (?),0x0E (?),0x0F (?),0x10 (?),0x11 (?),0x12 (?),0x13 (?),0x14 (?),0x15 (?),0x16 (?),0x17 (?),0x18 (?),0x19 (?),0x1A (?),0x1B (?),0x1C (?),0x1D (?),0x1E (?),0x1F (?),0x20 (?),0x21 (?),0x22 (?),0x23 (?),0x24 (?),0x25 (?),0x26 (?),0x27 (?),0x28 (?),0x29 (?),0x2A (?),0x2B (?),0x2C (?),0x2D (?),0x2E (?),0x2F (?),0x30 (?),0x31 (?),0x32 (?),0x33 (?),0x34 (?),0x35 (?),0x36 (?),0x37 (?),0x38 (?),0x39 (?),0x3A (?),0x3B (?),0x3C (?),0x3D (?),0x3E (?),0x3F (?)"
   textline ""
   bitfld.long 0x0   16.--21.     "[21 : 16]  LSB                                 = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?),0x08 (?),0x09 (?),0x0A (?),0x0B (?),0x0C (?),0x0D (?),0x0E (?),0x0F (?),0x10 (?),0x11 (?),0x12 (?),0x13 (?),0x14 (?),0x15 (?),0x16 (?),0x17 (?),0x18 (?),0x19 (?),0x1A (?),0x1B (?),0x1C (?),0x1D (?),0x1E (?),0x1F (?),0x20 (?),0x21 (?),0x22 (?),0x23 (?),0x24 (?),0x25 (?),0x26 (?),0x27 (?),0x28 (?),0x29 (?),0x2A (?),0x2B (?),0x2C (?),0x2D (?),0x2E (?),0x2F (?),0x30 (?),0x31 (?),0x32 (?),0x33 (?),0x34 (?),0x35 (?),0x36 (?),0x37 (?),0x38 (?),0x39 (?),0x3A (?),0x3B (?),0x3C (?),0x3D (?),0x3E (?),0x3F (?)"
   textline ""
   bitfld.long 0x0   15.          "[ 15 ]     BLED                                = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   12.--13.     "[13 : 12]  XPUT                                = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?)"
   textline ""
   bitfld.long 0x0   11.          "[ 11 ]     PT                                  = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   10.          "[ 10 ]     MV                                  = " "0x00 (?),0x01 (?)"
   textline ""
   hexmask.long.word 0 0.--9. 1   "[9 : 0]    NRG                                 = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0002D074$ PER_TESLA9X45_Part5.per -queue XPU_CFG_SNOC_CFG_XPU_IDR0"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0002D078
tree " XPU_CFG_SNOC_CFG_XPU_IDR1 [R]                                     0x0002D078"
  group.long 0x0--0x3
   textline "POR 0x1F090A1F    MASK = 0x7F3FFEFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print XPU_CFG_SNOC_CFG_XPU_IDR1 PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   30.          "[ 30 ]     AMT_HW_ENABLE                       = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   24.--29.     "[29 : 24]  CLIENT_ADDR_WIDTH                   = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?),0x08 (?),0x09 (?),0x0A (?),0x0B (?),0x0C (?),0x0D (?),0x0E (?),0x0F (?),0x10 (?),0x11 (?),0x12 (?),0x13 (?),0x14 (?),0x15 (?),0x16 (?),0x17 (?),0x18 (?),0x19 (?),0x1A (?),0x1B (?),0x1C (?),0x1D (?),0x1E (?),0x1F (?),0x20 (?),0x21 (?),0x22 (?),0x23 (?),0x24 (?),0x25 (?),0x26 (?),0x27 (?),0x28 (?),0x29 (?),0x2A (?),0x2B (?),0x2C (?),0x2D (?),0x2E (?),0x2F (?),0x30 (?),0x31 (?),0x32 (?),0x33 (?),0x34 (?),0x35 (?),0x36 (?),0x37 (?),0x38 (?),0x39 (?),0x3A (?),0x3B (?),0x3C (?),0x3D (?),0x3E (?),0x3F (?)"
   textline ""
   bitfld.long 0x0   16.--21.     "[21 : 16]  CONFIG_ADDR_WIDTH                   = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?),0x08 (?),0x09 (?),0x0A (?),0x0B (?),0x0C (?),0x0D (?),0x0E (?),0x0F (?),0x10 (?),0x11 (?),0x12 (?),0x13 (?),0x14 (?),0x15 (?),0x16 (?),0x17 (?),0x18 (?),0x19 (?),0x1A (?),0x1B (?),0x1C (?),0x1D (?),0x1E (?),0x1F (?),0x20 (?),0x21 (?),0x22 (?),0x23 (?),0x24 (?),0x25 (?),0x26 (?),0x27 (?),0x28 (?),0x29 (?),0x2A (?),0x2B (?),0x2C (?),0x2D (?),0x2E (?),0x2F (?),0x30 (?),0x31 (?),0x32 (?),0x33 (?),0x34 (?),0x35 (?),0x36 (?),0x37 (?),0x38 (?),0x39 (?),0x3A (?),0x3B (?),0x3C (?),0x3D (?),0x3E (?),0x3F (?)"
   textline ""
   bitfld.long 0x0   15.          "[ 15 ]     QRIB_EN                             = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   14.          "[ 14 ]     ASYNC_MODE                          = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   13.          "[ 13 ]     CONFIG_TYPE                         = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   12.          "[ 12 ]     CLIENT_PIPELINE_ENABLED             = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   11.          "[ 11 ]     MSA_CHECK_HW_ENABLE                 = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   10.          "[ 10 ]     XPU_SYND_REG_ABSENT                 = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   9.           "[ 9 ]      TZXPU                               = " "0x00 (?),0x01 (?)"
   textline ""
   hexmask.long.byte 0 0.--7. 1   "[7 : 0]    NVMID                               = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0002D078$ PER_TESLA9X45_Part5.per -queue XPU_CFG_SNOC_CFG_XPU_IDR1"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0002D07C
tree " XPU_CFG_SNOC_CFG_XPU_REV [R]                                      0x0002D07C"
  group.long 0x0--0x3
   textline "POR 0x20060000    MASK = 0xFFFFFFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print XPU_CFG_SNOC_CFG_XPU_REV PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   28.--31.     "[31 : 28]  MAJOR                               = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?),0x08 (?),0x09 (?),0x0A (?),0x0B (?),0x0C (?),0x0D (?),0x0E (?),0x0F (?)"
   textline ""
   hexmask.long.word 0 16.--27. 1 "[27 : 16]  MINOR                               = "
   textline ""
   hexmask.long.word 0 0.--15. 1  "[15 : 0]   STEP                                = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0002D07C$ PER_TESLA9X45_Part5.per -queue XPU_CFG_SNOC_CFG_XPU_REV"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0002D200
tree " XPU_CFG_SNOC_CFG_XPU_PRT0_RACR0 [RW] (n,m)[(0:0),(0:3)]           0x0002D200"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0xFFFFFFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print XPU_CFG_SNOC_CFG_XPU_PRT0_RACR0 PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.long 0 0.--31. 1  "[31 : 0]   RE                                  = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0002D200$ PER_TESLA9X45_Part5.per -queue XPU_CFG_SNOC_CFG_XPU_PRT0_RACR0"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0002D204
tree " XPU_CFG_SNOC_CFG_XPU_PRT0_RACR1 [RW] (n,m)[(0:0),(0:3)]           0x0002D204"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0xFFFFFFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print XPU_CFG_SNOC_CFG_XPU_PRT0_RACR1 PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.long 0 0.--31. 1  "[31 : 0]   RE                                  = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0002D204$ PER_TESLA9X45_Part5.per -queue XPU_CFG_SNOC_CFG_XPU_PRT0_RACR1"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0002D208
tree " XPU_CFG_SNOC_CFG_XPU_PRT0_RACR2 [RW] (n,m)[(0:0),(0:3)]           0x0002D208"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0xFFFFFFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print XPU_CFG_SNOC_CFG_XPU_PRT0_RACR2 PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.long 0 0.--31. 1  "[31 : 0]   RE                                  = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0002D208$ PER_TESLA9X45_Part5.per -queue XPU_CFG_SNOC_CFG_XPU_PRT0_RACR2"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0002D20C
tree " XPU_CFG_SNOC_CFG_XPU_PRT0_RACR3 [RW] (n,m)[(0:0),(0:3)]           0x0002D20C"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0xFFFFFFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print XPU_CFG_SNOC_CFG_XPU_PRT0_RACR3 PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.long 0 0.--31. 1  "[31 : 0]   RE                                  = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0002D20C$ PER_TESLA9X45_Part5.per -queue XPU_CFG_SNOC_CFG_XPU_PRT0_RACR3"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0002D220
tree " XPU_CFG_SNOC_CFG_XPU_PRT0_WACR0 [RW] (n,m)[(0:0),(0:3)]           0x0002D220"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0xFFFFFFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print XPU_CFG_SNOC_CFG_XPU_PRT0_WACR0 PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.long 0 0.--31. 1  "[31 : 0]   WE                                  = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0002D220$ PER_TESLA9X45_Part5.per -queue XPU_CFG_SNOC_CFG_XPU_PRT0_WACR0"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0002D224
tree " XPU_CFG_SNOC_CFG_XPU_PRT0_WACR1 [RW] (n,m)[(0:0),(0:3)]           0x0002D224"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0xFFFFFFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print XPU_CFG_SNOC_CFG_XPU_PRT0_WACR1 PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.long 0 0.--31. 1  "[31 : 0]   WE                                  = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0002D224$ PER_TESLA9X45_Part5.per -queue XPU_CFG_SNOC_CFG_XPU_PRT0_WACR1"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0002D228
tree " XPU_CFG_SNOC_CFG_XPU_PRT0_WACR2 [RW] (n,m)[(0:0),(0:3)]           0x0002D228"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0xFFFFFFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print XPU_CFG_SNOC_CFG_XPU_PRT0_WACR2 PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.long 0 0.--31. 1  "[31 : 0]   WE                                  = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0002D228$ PER_TESLA9X45_Part5.per -queue XPU_CFG_SNOC_CFG_XPU_PRT0_WACR2"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0002D22C
tree " XPU_CFG_SNOC_CFG_XPU_PRT0_WACR3 [RW] (n,m)[(0:0),(0:3)]           0x0002D22C"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0xFFFFFFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print XPU_CFG_SNOC_CFG_XPU_PRT0_WACR3 PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.long 0 0.--31. 1  "[31 : 0]   WE                                  = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0002D22C$ PER_TESLA9X45_Part5.per -queue XPU_CFG_SNOC_CFG_XPU_PRT0_WACR3"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0002D240
tree " XPU_CFG_SNOC_CFG_XPU_PRT0_START0 [RW] n[3:0]                      0x0002D240"
  group.long 0x0--0x3
   textline "POR 0x000FF000    MASK = 0x000FF000    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print XPU_CFG_SNOC_CFG_XPU_PRT0_START0 PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.byte 0 12.--19. 1 "[19 : 12]  ADDR                                = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0002D240$ PER_TESLA9X45_Part5.per -queue XPU_CFG_SNOC_CFG_XPU_PRT0_START0"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0002D2C0
tree " XPU_CFG_SNOC_CFG_XPU_PRT1_START0 [RW] n[3:0]                      0x0002D2C0"
  group.long 0x0--0x3
   textline "POR 0x000FF000    MASK = 0x000FF000    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print XPU_CFG_SNOC_CFG_XPU_PRT1_START0 PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.byte 0 12.--19. 1 "[19 : 12]  ADDR                                = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0002D2C0$ PER_TESLA9X45_Part5.per -queue XPU_CFG_SNOC_CFG_XPU_PRT1_START0"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0002D340
tree " XPU_CFG_SNOC_CFG_XPU_PRT2_START0 [RW] n[3:0]                      0x0002D340"
  group.long 0x0--0x3
   textline "POR 0x000FF000    MASK = 0x000FF000    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print XPU_CFG_SNOC_CFG_XPU_PRT2_START0 PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.byte 0 12.--19. 1 "[19 : 12]  ADDR                                = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0002D340$ PER_TESLA9X45_Part5.per -queue XPU_CFG_SNOC_CFG_XPU_PRT2_START0"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0002D3C0
tree " XPU_CFG_SNOC_CFG_XPU_PRT3_START0 [RW] n[3:0]                      0x0002D3C0"
  group.long 0x0--0x3
   textline "POR 0x000FF000    MASK = 0x000FF000    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print XPU_CFG_SNOC_CFG_XPU_PRT3_START0 PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.byte 0 12.--19. 1 "[19 : 12]  ADDR                                = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0002D3C0$ PER_TESLA9X45_Part5.per -queue XPU_CFG_SNOC_CFG_XPU_PRT3_START0"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0002D248
tree " XPU_CFG_SNOC_CFG_XPU_PRT0_END0 [RW] n[3:0]                        0x0002D248"
  group.long 0x0--0x3
   textline "POR 0x000FF000    MASK = 0x000FF000    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print XPU_CFG_SNOC_CFG_XPU_PRT0_END0 PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.byte 0 12.--19. 1 "[19 : 12]  ADDR                                = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0002D248$ PER_TESLA9X45_Part5.per -queue XPU_CFG_SNOC_CFG_XPU_PRT0_END0"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0002D2C8
tree " XPU_CFG_SNOC_CFG_XPU_PRT1_END0 [RW] n[3:0]                        0x0002D2C8"
  group.long 0x0--0x3
   textline "POR 0x000FF000    MASK = 0x000FF000    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print XPU_CFG_SNOC_CFG_XPU_PRT1_END0 PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.byte 0 12.--19. 1 "[19 : 12]  ADDR                                = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0002D2C8$ PER_TESLA9X45_Part5.per -queue XPU_CFG_SNOC_CFG_XPU_PRT1_END0"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0002D348
tree " XPU_CFG_SNOC_CFG_XPU_PRT2_END0 [RW] n[3:0]                        0x0002D348"
  group.long 0x0--0x3
   textline "POR 0x000FF000    MASK = 0x000FF000    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print XPU_CFG_SNOC_CFG_XPU_PRT2_END0 PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.byte 0 12.--19. 1 "[19 : 12]  ADDR                                = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0002D348$ PER_TESLA9X45_Part5.per -queue XPU_CFG_SNOC_CFG_XPU_PRT2_END0"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0002D3C8
tree " XPU_CFG_SNOC_CFG_XPU_PRT3_END0 [RW] n[3:0]                        0x0002D3C8"
  group.long 0x0--0x3
   textline "POR 0x000FF000    MASK = 0x000FF000    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print XPU_CFG_SNOC_CFG_XPU_PRT3_END0 PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.byte 0 12.--19. 1 "[19 : 12]  ADDR                                = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0002D3C8$ PER_TESLA9X45_Part5.per -queue XPU_CFG_SNOC_CFG_XPU_PRT3_END0"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0002D250
tree " XPU_CFG_SNOC_CFG_XPU_PRT0_SCR [RW] n[3:0]                         0x0002D250"
  group.long 0x0--0x3
   textline "POR 0x00000001    MASK = 0x0000003F    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print XPU_CFG_SNOC_CFG_XPU_PRT0_SCR PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   5.           "[ 5 ]      SCLROE                              = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   4.           "[ 4 ]      VMIDCLROE                           = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   3.           "[ 3 ]      MSACLROE                            = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   2.           "[ 2 ]      VMIDCLRWE                           = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   1.           "[ 1 ]      MSACLRWE                            = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   0.           "[ 0 ]      NS                                  = " "0x00 (?),0x01 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0002D250$ PER_TESLA9X45_Part5.per -queue XPU_CFG_SNOC_CFG_XPU_PRT0_SCR"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0002D2D0
tree " XPU_CFG_SNOC_CFG_XPU_PRT1_SCR [RW] n[3:0]                         0x0002D2D0"
  group.long 0x0--0x3
   textline "POR 0x00000001    MASK = 0x0000003F    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print XPU_CFG_SNOC_CFG_XPU_PRT1_SCR PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   5.           "[ 5 ]      SCLROE                              = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   4.           "[ 4 ]      VMIDCLROE                           = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   3.           "[ 3 ]      MSACLROE                            = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   2.           "[ 2 ]      VMIDCLRWE                           = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   1.           "[ 1 ]      MSACLRWE                            = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   0.           "[ 0 ]      NS                                  = " "0x00 (?),0x01 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0002D2D0$ PER_TESLA9X45_Part5.per -queue XPU_CFG_SNOC_CFG_XPU_PRT1_SCR"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0002D350
tree " XPU_CFG_SNOC_CFG_XPU_PRT2_SCR [RW] n[3:0]                         0x0002D350"
  group.long 0x0--0x3
   textline "POR 0x00000001    MASK = 0x0000003F    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print XPU_CFG_SNOC_CFG_XPU_PRT2_SCR PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   5.           "[ 5 ]      SCLROE                              = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   4.           "[ 4 ]      VMIDCLROE                           = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   3.           "[ 3 ]      MSACLROE                            = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   2.           "[ 2 ]      VMIDCLRWE                           = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   1.           "[ 1 ]      MSACLRWE                            = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   0.           "[ 0 ]      NS                                  = " "0x00 (?),0x01 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0002D350$ PER_TESLA9X45_Part5.per -queue XPU_CFG_SNOC_CFG_XPU_PRT2_SCR"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0002D3D0
tree " XPU_CFG_SNOC_CFG_XPU_PRT3_SCR [RW] n[3:0]                         0x0002D3D0"
  group.long 0x0--0x3
   textline "POR 0x00000001    MASK = 0x0000003F    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print XPU_CFG_SNOC_CFG_XPU_PRT3_SCR PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   5.           "[ 5 ]      SCLROE                              = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   4.           "[ 4 ]      VMIDCLROE                           = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   3.           "[ 3 ]      MSACLROE                            = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   2.           "[ 2 ]      VMIDCLRWE                           = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   1.           "[ 1 ]      MSACLRWE                            = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   0.           "[ 0 ]      NS                                  = " "0x00 (?),0x01 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0002D3D0$ PER_TESLA9X45_Part5.per -queue XPU_CFG_SNOC_CFG_XPU_PRT3_SCR"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0002D254
tree " XPU_CFG_SNOC_CFG_XPU_PRT0_MCR [RW] n[3:0]                         0x0002D254"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x0000003F    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print XPU_CFG_SNOC_CFG_XPU_PRT0_MCR PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   5.           "[ 5 ]      MSACLROE                            = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   4.           "[ 4 ]      VMIDCLROE                           = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   3.           "[ 3 ]      SCLROE                              = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   2.           "[ 2 ]      VMIDCLE                             = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   1.           "[ 1 ]      SCLE                                = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   0.           "[ 0 ]      MSAE                                = " "0x00 (?),0x01 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0002D254$ PER_TESLA9X45_Part5.per -queue XPU_CFG_SNOC_CFG_XPU_PRT0_MCR"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0002D2D4
tree " XPU_CFG_SNOC_CFG_XPU_PRT1_MCR [RW] n[3:0]                         0x0002D2D4"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x0000003F    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print XPU_CFG_SNOC_CFG_XPU_PRT1_MCR PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   5.           "[ 5 ]      MSACLROE                            = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   4.           "[ 4 ]      VMIDCLROE                           = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   3.           "[ 3 ]      SCLROE                              = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   2.           "[ 2 ]      VMIDCLE                             = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   1.           "[ 1 ]      SCLE                                = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   0.           "[ 0 ]      MSAE                                = " "0x00 (?),0x01 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0002D2D4$ PER_TESLA9X45_Part5.per -queue XPU_CFG_SNOC_CFG_XPU_PRT1_MCR"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0002D354
tree " XPU_CFG_SNOC_CFG_XPU_PRT2_MCR [RW] n[3:0]                         0x0002D354"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x0000003F    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print XPU_CFG_SNOC_CFG_XPU_PRT2_MCR PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   5.           "[ 5 ]      MSACLROE                            = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   4.           "[ 4 ]      VMIDCLROE                           = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   3.           "[ 3 ]      SCLROE                              = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   2.           "[ 2 ]      VMIDCLE                             = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   1.           "[ 1 ]      SCLE                                = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   0.           "[ 0 ]      MSAE                                = " "0x00 (?),0x01 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0002D354$ PER_TESLA9X45_Part5.per -queue XPU_CFG_SNOC_CFG_XPU_PRT2_MCR"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0002D3D4
tree " XPU_CFG_SNOC_CFG_XPU_PRT3_MCR [RW] n[3:0]                         0x0002D3D4"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x0000003F    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print XPU_CFG_SNOC_CFG_XPU_PRT3_MCR PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   5.           "[ 5 ]      MSACLROE                            = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   4.           "[ 4 ]      VMIDCLROE                           = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   3.           "[ 3 ]      SCLROE                              = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   2.           "[ 2 ]      VMIDCLE                             = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   1.           "[ 1 ]      SCLE                                = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   0.           "[ 0 ]      MSAE                                = " "0x00 (?),0x01 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0002D3D4$ PER_TESLA9X45_Part5.per -queue XPU_CFG_SNOC_CFG_XPU_PRT3_MCR"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0002D258
tree " XPU_CFG_SNOC_CFG_XPU_PRT0_CNTL0 [RW] n[3:0]                       0x0002D258"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x80000000    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print XPU_CFG_SNOC_CFG_XPU_PRT0_CNTL0 PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   31.          "[ 31 ]     PD                                  = " "0x00 (?),0x01 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0002D258$ PER_TESLA9X45_Part5.per -queue XPU_CFG_SNOC_CFG_XPU_PRT0_CNTL0"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0002D2D8
tree " XPU_CFG_SNOC_CFG_XPU_PRT1_CNTL0 [RW] n[3:0]                       0x0002D2D8"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x80000000    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print XPU_CFG_SNOC_CFG_XPU_PRT1_CNTL0 PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   31.          "[ 31 ]     PD                                  = " "0x00 (?),0x01 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0002D2D8$ PER_TESLA9X45_Part5.per -queue XPU_CFG_SNOC_CFG_XPU_PRT1_CNTL0"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0002D358
tree " XPU_CFG_SNOC_CFG_XPU_PRT2_CNTL0 [RW] n[3:0]                       0x0002D358"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x80000000    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print XPU_CFG_SNOC_CFG_XPU_PRT2_CNTL0 PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   31.          "[ 31 ]     PD                                  = " "0x00 (?),0x01 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0002D358$ PER_TESLA9X45_Part5.per -queue XPU_CFG_SNOC_CFG_XPU_PRT2_CNTL0"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0002D3D8
tree " XPU_CFG_SNOC_CFG_XPU_PRT3_CNTL0 [RW] n[3:0]                       0x0002D3D8"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x80000000    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print XPU_CFG_SNOC_CFG_XPU_PRT3_CNTL0 PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   31.          "[ 31 ]     PD                                  = " "0x00 (?),0x01 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0002D3D8$ PER_TESLA9X45_Part5.per -queue XPU_CFG_SNOC_CFG_XPU_PRT3_CNTL0"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0002D25C
tree " XPU_CFG_SNOC_CFG_XPU_PRT0_CNTL1 [W] n[3:0]                        0x0002D25C"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x00000003    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print XPU_CFG_SNOC_CFG_XPU_PRT0_CNTL1 PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   1.           "[ 1 ]      ASRC                                = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   0.           "[ 0 ]      CSRC                                = " "0x00 (?),0x01 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0002D25C$ PER_TESLA9X45_Part5.per -queue XPU_CFG_SNOC_CFG_XPU_PRT0_CNTL1"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0002D2DC
tree " XPU_CFG_SNOC_CFG_XPU_PRT1_CNTL1 [W] n[3:0]                        0x0002D2DC"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x00000003    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print XPU_CFG_SNOC_CFG_XPU_PRT1_CNTL1 PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   1.           "[ 1 ]      ASRC                                = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   0.           "[ 0 ]      CSRC                                = " "0x00 (?),0x01 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0002D2DC$ PER_TESLA9X45_Part5.per -queue XPU_CFG_SNOC_CFG_XPU_PRT1_CNTL1"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0002D35C
tree " XPU_CFG_SNOC_CFG_XPU_PRT2_CNTL1 [W] n[3:0]                        0x0002D35C"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x00000003    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print XPU_CFG_SNOC_CFG_XPU_PRT2_CNTL1 PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   1.           "[ 1 ]      ASRC                                = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   0.           "[ 0 ]      CSRC                                = " "0x00 (?),0x01 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0002D35C$ PER_TESLA9X45_Part5.per -queue XPU_CFG_SNOC_CFG_XPU_PRT2_CNTL1"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0002D3DC
tree " XPU_CFG_SNOC_CFG_XPU_PRT3_CNTL1 [W] n[3:0]                        0x0002D3DC"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x00000003    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print XPU_CFG_SNOC_CFG_XPU_PRT3_CNTL1 PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   1.           "[ 1 ]      ASRC                                = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   0.           "[ 0 ]      CSRC                                = " "0x00 (?),0x01 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0002D3DC$ PER_TESLA9X45_Part5.per -queue XPU_CFG_SNOC_CFG_XPU_PRT3_CNTL1"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00033000
tree " XPU_CFG_RPM_CFG_XPU_SCR [RW]                                      0x00033000"
  group.long 0x0--0x3
   textline "POR 0x00000106    MASK = 0x0000077F    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print XPU_CFG_RPM_CFG_XPU_SCR PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   10.          "[ 10 ]     SCLEIE                              = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   9.           "[ 9 ]      SCFGEIE                             = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   8.           "[ 8 ]      DYNAMIC_CLK_EN                      = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   6.           "[ 6 ]      NSRGCLEE                            = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   5.           "[ 5 ]      NSCFGE                              = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   4.           "[ 4 ]      SDCDEE                              = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   3.           "[ 3 ]      SEIE                                = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   2.           "[ 2 ]      SCLERE                              = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   1.           "[ 1 ]      SCFGERE                             = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   0.           "[ 0 ]      XPUNSE                              = " "0x00 (?),0x01 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00033000$ PER_TESLA9X45_Part5.per -queue XPU_CFG_RPM_CFG_XPU_SCR"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00033004
tree " XPU_CFG_RPM_CFG_XPU_SWDR [RW]                                     0x00033004"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x00000001    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print XPU_CFG_RPM_CFG_XPU_SWDR PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   0.           "[ 0 ]      SCFGWD                              = " "0x00 (?),0x01 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00033004$ PER_TESLA9X45_Part5.per -queue XPU_CFG_RPM_CFG_XPU_SWDR"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00033008
tree " XPU_CFG_RPM_CFG_XPU_PRTN_RACR_SSHADOW [RW]                        0x00033008"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0xFFFFFFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print XPU_CFG_RPM_CFG_XPU_PRTN_RACR_SSHADOW PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.long 0 0.--31. 1  "[31 : 0]   RE                                  = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00033008$ PER_TESLA9X45_Part5.per -queue XPU_CFG_RPM_CFG_XPU_PRTN_RACR_SSHADOW"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0003300C
tree " XPU_CFG_RPM_CFG_XPU_PRTN_WACR_SSHADOW [RW]                        0x0003300C"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0xFFFFFFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print XPU_CFG_RPM_CFG_XPU_PRTN_WACR_SSHADOW PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.long 0 0.--31. 1  "[31 : 0]   WE                                  = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0003300C$ PER_TESLA9X45_Part5.per -queue XPU_CFG_RPM_CFG_XPU_PRTN_WACR_SSHADOW"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00033010
tree " XPU_CFG_RPM_CFG_XPU_PRTN_START_SSHADOW0 [RW]                      0x00033010"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x003FF000    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print XPU_CFG_RPM_CFG_XPU_PRTN_START_SSHADOW0 PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.word 0 12.--21. 1 "[21 : 12]  ADDR                                = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00033010$ PER_TESLA9X45_Part5.per -queue XPU_CFG_RPM_CFG_XPU_PRTN_START_SSHADOW0"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00033018
tree " XPU_CFG_RPM_CFG_XPU_PRTN_END_SSHADOW0 [RW]                        0x00033018"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x003FF000    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print XPU_CFG_RPM_CFG_XPU_PRTN_END_SSHADOW0 PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.word 0 12.--21. 1 "[21 : 12]  ADDR                                = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00033018$ PER_TESLA9X45_Part5.per -queue XPU_CFG_RPM_CFG_XPU_PRTN_END_SSHADOW0"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00033040
tree " XPU_CFG_RPM_CFG_XPU_SEAR0 [R]                                     0x00033040"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0xFFFFFFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print XPU_CFG_RPM_CFG_XPU_SEAR0 PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.long 0 0.--31. 1  "[31 : 0]   PA                                  = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00033040$ PER_TESLA9X45_Part5.per -queue XPU_CFG_RPM_CFG_XPU_SEAR0"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00033048
tree " XPU_CFG_RPM_CFG_XPU_SESR [RW]                                     0x00033048"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x8000000F    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print XPU_CFG_RPM_CFG_XPU_SESR PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   31.          "[ 31 ]     MULTI                               = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   3.           "[ 3 ]      CLMULTI                             = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   2.           "[ 2 ]      CFGMULTI                            = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   1.           "[ 1 ]      CLIENT                              = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   0.           "[ 0 ]      CFG                                 = " "0x00 (?),0x01 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00033048$ PER_TESLA9X45_Part5.per -queue XPU_CFG_RPM_CFG_XPU_SESR"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x0003304C
tree " XPU_CFG_RPM_CFG_XPU_SESRRESTORE [RW]                              0x0003304C"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x8000000F    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print XPU_CFG_RPM_CFG_XPU_SESRRESTORE PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   31.          "[ 31 ]     MULTI                               = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   3.           "[ 3 ]      CLMULTI                             = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   2.           "[ 2 ]      CFGMULTI                            = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   1.           "[ 1 ]      CLIENT                              = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   0.           "[ 0 ]      CFG                                 = " "0x00 (?),0x01 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x0003304C$ PER_TESLA9X45_Part5.per -queue XPU_CFG_RPM_CFG_XPU_SESRRESTORE"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00033050
tree " XPU_CFG_RPM_CFG_XPU_SESYNR0 [R]                                   0x00033050"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0xFFFFFFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print XPU_CFG_RPM_CFG_XPU_SESYNR0 PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   hexmask.long.byte 0 24.--31. 1 "[31 : 24]  ATID                                = "
   textline ""
   hexmask.long.byte 0 16.--23. 1 "[23 : 16]  AVMID                               = "
   textline ""
   bitfld.long 0x0   13.--15.     "[15 : 13]  ABID                                = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?)"
   textline ""
   bitfld.long 0x0   8.--12.      "[12 : 8]   APID                                = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?),0x08 (?),0x09 (?),0x0A (?),0x0B (?),0x0C (?),0x0D (?),0x0E (?),0x0F (?),0x10 (?),0x11 (?),0x12 (?),0x13 (?),0x14 (?),0x15 (?),0x16 (?),0x17 (?),0x18 (?),0x19 (?),0x1A (?),0x1B (?),0x1C (?),0x1D (?),0x1E (?),0x1F (?)"
   textline ""
   hexmask.long.byte 0 0.--7. 1   "[7 : 0]    AMID                                = "
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00033050$ PER_TESLA9X45_Part5.per -queue XPU_CFG_RPM_CFG_XPU_SESYNR0"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00033054
tree " XPU_CFG_RPM_CFG_XPU_SESYNR1 [R]                                   0x00033054"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0xFFFFFFFF    "
   button "Add to Search History" "do &dp_cmm_path\PER_Print XPU_CFG_RPM_CFG_XPU_SESYNR1 PER_TESLA9X45_Part5.per -history"
   textfld "    "
   button "Search - F12" "do &dp_cmm_path\PER_Find --PER_TESLA9X45_Part5.per"
   textline ""
   line.long 0x0 "VALUE"
   textline ""
   bitfld.long 0x0   31.          "[ 31 ]     DCD                                 = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   30.          "[ 30 ]     AC                                  = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   29.          "[ 29 ]     BURSTLEN                            = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   28.          "[ 28 ]     ARDALLOCATE                         = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   27.          "[ 27 ]     ABURST                              = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   26.          "[ 26 ]     AEXCLUSIVE                          = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   25.          "[ 25 ]     AWRITE                              = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   24.          "[ 24 ]     AFULL                               = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   23.          "[ 23 ]     ARDBEADNDXEN                        = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   22.          "[ 22 ]     AOOO                                = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   19.--21.     "[21 : 19]  APREQPRIORITY                       = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?)"
   textline ""
   bitfld.long 0x0   16.--18.     "[18 : 16]  ASIZE                               = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?)"
   textline ""
   bitfld.long 0x0   15.          "[ 15 ]     AMSSSELFAUTH                        = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   8.--14.      "[14 : 8]   ALEN                                = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?),0x08 (?),0x09 (?),0x0A (?),0x0B (?),0x0C (?),0x0D (?),0x0E (?),0x0F (?),0x10 (?),0x11 (?),0x12 (?),0x13 (?),0x14 (?),0x15 (?),0x16 (?),0x17 (?),0x18 (?),0x19 (?),0x1A (?),0x1B (?),0x1C (?),0x1D (?),0x1E (?),0x1F (?),0x20 (?),0x21 (?),0x22 (?),0x23 (?),0x24 (?),0x25 (?),0x26 (?),0x27 (?),0x28 (?),0x29 (?),0x2A (?),0x2B (?),0x2C (?),0x2D (?),0x2E (?),0x2F (?),0x30 (?),0x31 (?),0x32 (?),0x33 (?),0x34 (?),0x35 (?),0x36 (?),0x37 (?),0x38 (?),0x39 (?),0x3A (?),0x3B (?),0x3C (?),0x3D (?),0x3E (?),0x3F (?),0x40 (?),0x41 (?),0x42 (?),0x43 (?),0x44 (?),0x45 (?),0x46 (?),0x47 (?),0x48 (?),0x49 (?),0x4A (?),0x4B (?),0x4C (?),0x4D (?),0x4E (?),0x4F (?),0x50 (?),0x51 (?),0x52 (?),0x53 (?),0x54 (?),0x55 (?),0x56 (?),0x57 (?),0x58 (?),0x59 (?),0x5A (?),0x5B (?),0x5C (?),0x5D (?),0x5E (?),0x5F (?),0x60 (?),0x61 (?),0x62 (?),0x63 (?),0x64 (?),0x65 (?),0x66 (?),0x67 (?),0x68 (?),0x69 (?),0x6A (?),0x6B (?),0x6C (?),0x6D (?),0x6E (?),0x6F (?),0x70 (?),0x71 (?),0x72 (?),0x73 (?),0x74 (?),0x75 (?),0x76 (?),0x77 (?),0x78 (?),0x79 (?),0x7A (?),0x7B (?),0x7C (?),0x7D (?),0x7E (?),0x7F (?)"
   textline ""
   bitfld.long 0x0   7.           "[ 7 ]      AINST                               = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   6.           "[ 6 ]      APROTNS                             = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   5.           "[ 5 ]      APRIV                               = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   4.           "[ 4 ]      AINNERSHARED                        = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   3.           "[ 3 ]      ASHARED                             = " "0x00 (?),0x01 (?)"
   textline ""
   bitfld.long 0x0   0.--2.       "[2 : 0]    AMEMTYPE                            = " "0x00 (?),0x01 (?),0x02 (?),0x03 (?),0x04 (?),0x05 (?),0x06 (?),0x07 (?)"
   textline ""
   button "Dump Content:" "OS notepad C:\dropbox\PER_REG_DUMP.txt"
   button "Push " "do &dp_cmm_path\PER_Print $0x00033054$ PER_TESLA9X45_Part5.per -queue XPU_CFG_RPM_CFG_XPU_SESYNR1"
   button " Hit " "do &dp_cmm_path\PER_Print -batch_Dump"
   button "Arise" "OS notepad C:\dropbox\batch_reg_dump.txt"
   button "Move " "do &dp_cmm_path\PER_Print Dump_batch"
tree.end

base A:0x00033058
tree " XPU_CFG_RPM_CFG_XPU_SESYNR2 [R]                                   0x00033058"
  group.long 0x0--0x3
   textline "POR 0x00000000    MASK = 0x00000007    "
